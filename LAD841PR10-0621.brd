# Allegro board LAD841PR10-0621.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
TVNST52302AB0_SOT523-3
  oval 0.508x0.559 smd: 1(0,0) 2(-0.5,-1.4) 3(0.5,-1.4)
W25Q64FVZPIG_WSON8_6X5
  oval 0.66x1.092 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.9) 6(2.54,5.9) 7(1.27,5.9) 8(0,5.9)
  rect 4.293x3.404 smd: 9(1.905,2.95)
W25Q80DVZPIG_WSON8
  oval 0.66x1.092 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.9) 6(2.54,5.9) 7(1.27,5.9) 8(0,5.9)
  rect 4.293x3.404 smd: 9(1.905,2.95)
W25Q256FVEIG_WSON8
  oval 0.66x0.991 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,8) 6(2.54,8) 7(1.27,8) 8(0,8)
  rect 4.293x3.404 smd: 9(1.905,4)
Y_7V25000014_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
Y_9H03220008_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_Q13FC135000040_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_X3G024000DC1H_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)

## Nets
1.0VA_PG: PR705.2 PU700.2
1.2V_DDR_OT: PR600.1 PU600.19
1.2V_DDR_PG: PR601.1 PU600.18
1.8VA_PWROK: PR805.1 PU800.4
1.8VU_PWROK: PR905.1 PU900.4
3.3V_CAM_EN#: QZ9.2 R1179.1 UCPU1.AT15
3.3V_TS_EN: R1162.1 UCPU1.AP5 UZ26.4
3V_FB: PC511.1 PU500.13
3V_SN: PC510.1 PR501.2
5V_FB: PC525.1 PU501.13
5V_SN: PC524.1 PR507.2
+0.6VS: CD129.1 CD132.1 CD133.1 CD135.1 CD136.1 CD139.1 CD140.1 CD142.1 CD196.1 CD197.1 PJP601.2 RD35.2 RD36.2 RD37.2 RD38.2 RD45.2 RD46.2 RD47.2 RD48.2 RD59.2 RD60.2 RD61.2 RD62.2 RD63.2 RD64.2 RD65.2 RD66.2 RD67.2 RD68.2 RD69.2 RD70.2 RD71.2 RD72.2 RD73.2 RD74.2 RD75.2 RD76.2 RD77.2 RD78.2 RD79.2 RD80.2 RD81.2 RD82.2 RD83.2 RD84.2 RD85.2 RD86.2 RD87.2 RD88.2 RD89.2 RD90.2 RD91.2 RD92.2 RD93.2 RD94.2 RD95.2 RD96.2 RD97.2 RD98.2 RD99.2 RD100.2 RD101.2 RD102.2 RD103.2 RD104.2 RD105.2 RD106.2 RD107.2 RD108.2 RD109.2 RD110.2 RD117.2 RD118.2
+0.6VSP: PC615.1 PC616.1 PJP601.1 PU600.5 PU600.6
+1.0V_AMPHYPLL: CC264.1 RC169.2 UCPU1.K15 UCPU1.L15
+1.0V_APLL: R10.1 RC172.2 UCPU1.V15
+1.0V_APLLEBB: CC218.1 RC310.2 UCPU1.N18
+1.0V_CLK: CC220.1 RC52.2 RC170.2 UCPU1.A10 UCPU1.A14 UCPU1.K19 UCPU1.L19 UCPU1.L21 UCPU1.N20
+1.0V_DTS: RC301.2 UCPU1.T1
+1.0V_MPHYAON: CC203.1 RC299.2 UCPU1.K17 UCPU1.L1
+1.0V_MPHYGT: CC210.1 CC211.1 CZ85.1 R1335.2 RC169.1 RC309.1 RC310.1 UCPU1.N15 UCPU1.N16 UCPU1.N17 UCPU1.P15 UCPU1.P16
+1.0V_PRIM_CORE: CC205.1 CC274.1 PJP1401.2 UCPU1.AF18 UCPU1.AF19 UCPU1.V20 UCPU1.V21
+1.0V_PRIM_COREP: PC1406.1 PC1415.1 PC1416.1 PJP1401.1 PL1403.2 PR1421.2 PU1401.1
+1.0V_SRAM: CC217.1 RC309.2 UCPU1.AF20 UCPU1.AF21 UCPU1.T19 UCPU1.T20
+1.0V_VCCST: CC195.1 CC202.1 CZ78.1 PC1004.1 PR1063.1 PR1074.1 PR1084.1 R1327.2 RC71.1 RC79.1 RC80.1 RC120.2 RC152.1 RC157.1 RC158.1 RC218.1 RT242.1 UCPU1.A18 UCPU1.K20 UCPU1.K21
+1.0V_VCCSTG: CC199.1 CZ82.1 PR401.1 PR1525.1 R1325.2 RC81.1 RC82.1 RC83.1 RC87.2 RC130.1 RC131.1 RC134.1 RC135.1 RC143.2 UCPU1.A22
+1.0V_VCCSTG_R: RC143.1 UCPU1.G20
+1.0VA: CC206.1 CC273.1 CZ84.1 CZ87.1 CZ92.1 PJP700.2 R1335.1 RC170.1 RC172.1 RC216.1 RC299.1 RC301.1 UCPU1.AB17 UCPU1.AB19 UCPU1.AB20 UCPU1.AK20 UCPU1.P18 UCPU1.Y18 UZ19.1 UZ19.2 UZ19.7 UZ25.1 UZ25.2 UZ25.7
+1.0VA_XDP: CC28.1 CC29.1 JXDP1.43 JXDP1.44 RC115.2 RC138.1 RC216.2
+1.0VAP: PC707.1 PC708.1 PC709.1 PC710.1 PC711.1 PJP700.1 PL701.2 PR704.1
+1.0VS_VCCIO: CC181.1 CC182.1 CC185.1 CC186.1 CC248.1 CC249.1 CC250.1 CC251.1 CC252.1 CC253.1 PJP1400.2 RC2.1 RC132.1 RC165.1 RE70.1 UCPU1.AK28 UCPU1.AK30 UCPU1.AL30 UCPU1.AL42 UCPU1.AM28 UCPU1.AM30 UCPU1.AM42
+1.0VS_VCCIOP: PC1403.1 PC1404.1 PC1405.1 PJP1400.1 PL1401.2 PR1408.1 PU1400.1
+1.2V_DDR: CC31.1 CC34.1 CC35.1 CC174.1 CC175.1 CC176.1 CC177.1 CC178.1 CC179.1 CC194.1 CC240.1 CC256.1 CC257.1 CC258.1 CC259.1 CC260.1 CD1.1 CD2.1 CD3.1 CD4.1 CD5.1 CD6.1 CD7.1 CD8.1 CD29.1 CD30.1 CD33.1 CD34.1 CD37.1 CD41.1 CD57.1 CD58.1 CD59.1 CD60.1 CD61.1 CD62.1 CD63.1 CD64.1 CD85.1 CD86.1 CD87.1 CD88.1 CD89.1 CD91.1 CD148.1 CD149.1 CD150.1 CD151.1 CD152.1 CD153.1 CD154.1 CD155.1 CD156.1 CD157.1 CD158.1 CD159.1 CD160.1 CD161.1 CD166.1 CD167.1 CD168.1 CD169.1 CD170.1 CD171.1 CD172.1 CD173.1 CD174.1 CD175.1 CD176.1 CD177.1 CD178.1 CD179.1 CD182.1 CZ89.1 PJP600.2 RC171.1 RD17.1 RD21.1 RD22.1 UC2.5 UCPU1.AU23 UCPU1.AU28 UCPU1.AU35 UCPU1.AU42 UCPU1.BB23 UCPU1.BB32 UCPU1.BB41 UCPU1.BB47 UCPU1.BB51 UD19.A8 UD19.A9 UD19.A11 UD19.C12 UD19.D4 UD19.D5 UD19.D6 UD19.E8 UD19.E12 UD19.F2 UD19.G2 UD19.G5 UD19.G12 UD19.H3 UD19.H5 UD19.H6 UD19.H8 UD19.H9 UD19.H11 UD19.H12 UD19.J5 UD19.J6 UD19.J9 UD19.J10 UD19.K5 UD19.K6 UD19.K8 UD19.K11 UD19.K12 UD19.L2 UD19.L5 UD19.L12 UD19.M2 UD19.N8 UD19.N12 UD19.P4 UD19.P5 UD19.P6 UD19.R12 UD19.U8 UD19.U9 UD19.U11 UD20.A8 UD20.A9 UD20.A11 UD20.C12 UD20.D4 UD20.D5 UD20.D6 UD20.E8 UD20.E12 UD20.F2 UD20.G2 UD20.G5 UD20.G12 UD20.H3 UD20.H5 UD20.H6 UD20.H8 UD20.H9 UD20.H11 UD20.H12 UD20.J5 UD20.J6 UD20.J9 UD20.J10 UD20.K5 UD20.K6 UD20.K8 UD20.K11 UD20.K12 UD20.L2 UD20.L5 UD20.L12 UD20.M2 UD20.N8 UD20.N12 UD20.P4 UD20.P5 UD20.P6 UD20.R12 UD20.U8 UD20.U9 UD20.U11 UD21.A8 UD21.A9 UD21.A11 UD21.C12 UD21.D4 UD21.D5 UD21.D6 UD21.E8 UD21.E12 UD21.F2 UD21.G2 UD21.G5 UD21.G12 UD21.H3 UD21.H5 UD21.H6 UD21.H8 UD21.H9 UD21.H11 UD21.H12 UD21.J5 UD21.J6 UD21.J9 UD21.J10 UD21.K5 UD21.K6 UD21.K8 UD21.K11 UD21.K12 UD21.L2 UD21.L5 UD21.L12 UD21.M2 UD21.N8 UD21.N12 UD21.P4 UD21.P5 UD21.P6 UD21.R12 UD21.U8 UD21.U9 UD21.U11 UD22.A8 UD22.A9 UD22.A11 UD22.C12 UD22.D4 UD22.D5 UD22.D6 UD22.E8 UD22.E12 UD22.F2 UD22.G2 UD22.G5 UD22.G12 UD22.H3 UD22.H5 UD22.H6 UD22.H8 UD22.H9 UD22.H11 UD22.H12 UD22.J5 UD22.J6 UD22.J9 UD22.J10 UD22.K5 UD22.K6 UD22.K8 UD22.K11 UD22.K12 UD22.L2 UD22.L5 UD22.L12 UD22.M2 UD22.N8 UD22.N12 UD22.P4 UD22.P5 UD22.P6 UD22.R12 UD22.U8 UD22.U9 UD22.U11 UZ22.1 UZ22.2 UZ22.7
+1.2V_DDRP: PC608.1 PC609.1 PC610.1 PC611.1 PC612.1 PC613.1 PJP600.1 PL601.2 PR603.1 PU600.7 PU600.8
+1.2V_MEM_CPUCLK: RC171.2 UCPU1.AM40
+1.8V_PGPP: RC304.2 UCPU1.AF16
+1.8VA: C1169.1 CC212.1 CC272.1 PJP800.2 R79.1 R1334.1 RC304.1 RH144.2 RH149.2 RH150.2 RH151.2 RH152.2 U664.6 U664.7 UCPU1.AA1
+1.8VAP: PC801.1 PC802.1 PJP800.1 PL801.2 PR802.1 PR806.2 PU800.14
+1.8VS_AUDIO: C1217.1 CA78.1 CA83.1 R1125.2 RA63.1 RA81.1 RA82.1 UA2.36
+1.8VU: CD38.1 CD42.1 CD90.1 CD92.1 CD143.1 CD144.1 CD145.1 CD146.1 CD147.1 CD162.1 CD163.1 CD164.1 CD165.1 PJP900.2 UD19.A3 UD19.A4 UD19.A5 UD19.A6 UD19.A10 UD19.U3 UD19.U4 UD19.U5 UD19.U6 UD19.U10 UD20.A3 UD20.A4 UD20.A5 UD20.A6 UD20.A10 UD20.U3 UD20.U4 UD20.U5 UD20.U6 UD20.U10 UD21.A3 UD21.A4 UD21.A5 UD21.A6 UD21.A10 UD21.U3 UD21.U4 UD21.U5 UD21.U6 UD21.U10 UD22.A3 UD22.A4 UD22.A5 UD22.A6 UD22.A10 UD22.U3 UD22.U4 UD22.U5 UD22.U6 UD22.U10
+1.8VUP: PC901.1 PC902.1 PJP900.1 PL901.2 PR902.1 PR906.2 PU900.14
+3.3V_ALW_DEG: JDEG1.1 RE76.2
+3.3V_PGPP: CC265.1 CC267.1 CC268.1 RC211.2 UCPU1.AD15 UCPU1.AG15 UCPU1.AK15 UCPU1.T16 UCPU1.Y15 UCPU1.Y16
+3.3V_SPI: RC213.2 UCPU1.AJ16
+3.3VDX_SSD: C719.1 C720.1 C721.1 C722.1 C1164.1 C1304.1 JNGFF2.2 JNGFF2.4 JNGFF2.12 JNGFF2.14 JNGFF2.16 JNGFF2.18 JNGFF2.62 JNGFF2.64 JNGFF2.66 R1326.2 R1376.1 R1377.2
+3V_LDO: PC210.1 PQ222.1 PR281.1 PU202.5
+3V_PCH: C1161.1 CC10.1 CC209.1 CC223.1 CC224.1 JAPS1.1 JSPI1.15 R9.1 R1342.2 R1393.1 RC12.2 RC13.1 RC14.2 RC15.2 RC17.2 RC23.2 RC25.2 RC26.2 RC64.1 RC73.2 RC74.1 RC133.1 RC183.1 RC184.1 RC185.2 RC186.1 RC187.1 RC188.2 RC189.2 RC191.2 RC211.1 RC213.1 RC236.1 RC283.1 RC284.1 RC285.1 RC288.1 RH58.1 RH59.1 RH148.1 U18.8 UCPU1.AJ19 UCPU1.AJ21 UCPU1.AK17 UCPU1.V19
+3V_PCH_DSW: CC279.1 CC280.1 RC67.1 RC72.2 RC95.1 RC214.2 RC241.1 RC243.2 UCPU1.AD17 UCPU1.AD18 UCPU1.AJ17
+3V_TBT: CT52.1 CT53.1 CT54.1 CT55.1 CT56.1 LT14.2 RT21.1 RT26.1 RT33.1 RT34.1 RT46.2 RT51.1 RT52.1 RT114.2 RT241.2 UT1.A2 UT1.A3 UT1.B3 UT1.H9
+3V_TBT_PWR: CZ90.1 RT114.1 UZ23.6
+3V_TBT_S0: CT163.1 CT164.1 CT165.1 LT14.1 UT1.R13
+3V_VC: C1354.1 PC218.1 PQ221.3 PQ222.3 PQ223.5 PR255.1 PR256.1 PR257.1 PR259.1 PR260.1 PR261.1 PR275.1 PR278.1 PR281.2 PU203.8 U722.B1 U722.H1
+3VA_TBT: CT57.1 QT19.2 R1462.1 RT22.1 RT23.1 RT25.1 RT35.1 RT36.1 RT46.1 RT47.1 RT113.1 UT1.F8
+3VA_TBT_LC: CT50.1 RT6.1 RT7.1 RT8.1 RT9.1 UT1.R6
+3VALW: C375.1 C1158.1 C1160.1 C1162.1 C1166.1 C1168.1 C1203.1 C1213.1 C1254.1 C1256.1 C1289.1 C1322.1 CC271.1 CE4.1 CE42.1 CZ91.1 JAPS1.3 JAPS1.7 JIO1.49 JKB1.3 PC400.1 PC401.1 PC402.1 PC405.1 PC606.1 PC713.1 PJP14.1 PJP15.1 PJP500.2 PQ221.1 PR100.1 PR102.1 PR224.1 PR226.1 PR252.1 PR253.1 PR254.1 PR403.1 PR404.1 PR410.1 PR411.1 PR604.1 PR705.1 PR708.1 PR1404.1 PR1405.1 PR1414.1 PR1415.1 PR1423.1 PR1424.1 PR1503.1 PR1504.1 PR1522.1 PR1523.1 PU201.8 PU400.8 PU401.5 PU402.5 PU600.13 PU700.7 Q41.2 QH8.2 QH8.5 QH9.2 QH9.5 R2672.2 RC66.1 RC214.1 RE84.1 RT113.2 U664.1 U664.2 U699.5 U716.1 U716.2 U716.6 U716.7 U717.1 U717.2 U717.6 U717.7 U720.1 U720.2 U720.6 U720.7 U729.5 UC8.5 UC9.5 UC10.5 UC11.5 UC13.5 UZ23.1 UZ23.2 UZ23.7 UZ24.5 UZ26.1 UZ26.2 UZ26.7
+3VALW_5085: CE14.1 CE17.1 CE38.1 CE40.1 CE41.1 CE43.1 CE46.1 CE63.1 CE64.1 CE70.2 CE71.2 CE72.1 PJP15.2 RE3.1 RE25.1 RE52.1 RE53.1 RE55.2 RE56.2 RE65.1 RE67.2 RE69.1 RE71.2 RE72.1 RE73.2 RE74.1 RE75.1 RE76.1 RE79.1 RE81.1 RE86.2 RE87.2 RE88.2 RE93.2 RE102.1 RPE5.7 RPE5.8 RPE7.5 RPE7.6 RPE7.7 RPE7.8 UE5.A11 UE5.A22 UE5.A26 UE5.A41 UE5.A52 UE5.A58 UE5.B3 UE5.B35
+3VALW_23017: CE3.1 CE10.1 PJP14.2 RE13.1 RE14.1 RE24.1 RE27.1 UE4.5
+3VALWP: PC505.1 PC506.1 PC507.1 PC508.1 PC526.1 PJP500.1 PL501.2 PR502.1 PR504.2 PU500.14
+3VLP: D122.2 PC509.1 PU500.16 PU500.17 RE57.2
+3VS: C377.1 C1204.1 C1216.1 C1324.1 CS44.1 JEDP.40 JIO1.50 JKB1.4 JLPDE1.1 JLPDE1.2 PR600.2 PR601.2 PR805.2 PR905.2 PR1095.1 QC2.2 QC2.5 QZ9.3 R81.1 R220.1 R884.2 R1103.2 R1141.2 R1178.2 R1179.2 R1329.2 RC16.1 RC21.1 RC27.1 RC47.1 RC49.1 RC50.1 RC59.1 RC63.1 RC137.1 RC175.2 RC176.2 RC177.2 RC178.2 RC190.1 RC225.1 RC228.1 RC237.1 RC245.1 RC246.1 RC272.1 RC277.1 RC280.2 RC291.1 RC292.1 RE60.1 RE83.1 RH440.2 RH441.2 RH562.1 RH563.1 RN19.1 RN20.1 RT241.1 U683.5 UC7.5 UC12.5
+3VS_AUDIO: C1218.1 LA14.1 R1318.2 RA18.1 RA19.1 RA37.1 RA38.1 RA80.2 RC9.1
+3VS_CAM: C4.1 C1220.1 C1221.1 JCAM.1 R2670.2
+3VS_CR: C1264.1 C1325.1 JEDP.7 JIO1.45 JIO1.46 JIO1.47 JIO1.48 R1343.2
+3VS_NGFF: C712.1 C713.1 C715.1 C716.1 C1215.1 C1297.1 C1298.1 JNGFF1.2 JNGFF1.4 JNGFF1.64 JNGFF1.66 R80.1 R1344.2
+3VS_TP: C7.1 C1159.1 C1225.1 JTP1.1 Q40.2 QH7.2 QH7.5 R1104.2 R1105.2 R1299.1 R1323.2 RE6.1 RE7.1
+3VS_TPM: C94.1 C95.1 C96.1 C97.1 Q72.3 R1393.2 RC229.1 RH126.1 U15.14 U15.22
+3VS_TS: C8.1 C1208.1 R2671.2 RH357.1 U728.1 U728.3
+3VS_TSLDO: C5.1 C1222.1 C1223.1 JTS.6 RH357.2 U728.5
+5V_USB_P2: C3.1 C265.1 C303.1 JUSB2.1 US2.6 US2.7 US2.8
+5VALW: C2.1 C376.1 C962.1 C963.1 C1199.1 C1201.1 C1321.1 C1347.1 C1348.1 C1349.1 C1350.1 CZ86.1 JIO1.52 JIO1.53 JIO1.54 JIO1.55 JIO1.56 JIO1.57 JIO1.58 JIO1.59 JIO1.60 JIO1.61 JKB1.1 LED10.2 LED11.2 LED12.2 LED13.2 LED14.2 PJP501.2 PR105.2 PR1080.2 PR1127.2 PR1128.2 U664.4 U716.4 U717.4 U719.1 U719.2 U719.4 U719.6 U719.7 U720.4 U722.A11 U722.B11 U722.C11 U722.D11 U722.H10 US2.2 US2.3 UZ19.3 UZ22.3 UZ23.3 UZ25.3 UZ26.3
+5VALWP: PC518.1 PC519.1 PC520.1 PC521.1 PC522.1 PC527.1 PJP501.1 PL504.2 PR511.2 PU501.14
+5VS: C352.1 C1102.2 JFAN1.4 JKB1.2 JUART.1 PC1097.1 PC1114.1 PC1119.1 PC1129.1 PU1100.2 PU1101.2 PU1102.2 PU1305.6 R886.2 R2669.2
+5VS_AUDIO: C1200.1 CA97.1 CA98.1 CA111.1 CA112.1 LA2.2 LA3.1 LA4.2 R1320.2
+AVDD1: CA101.1 CA102.1 CA103.1 LA3.2 UA2.26
+AVDD2: CA80.1 CA82.1 RA63.2 UA2.40
+DVDD: CA4.1 CA5.1 CA31.1 CA42.1 LA14.2 RA76.1 RA81.2 UA2.1
+DVDDIO: CA6.1 CA7.1 CA104.1 CA105.1 RA80.1 RA82.2 UA2.9
+PVDD1: CA2.1 CA3.1 LA4.1 UA2.41
+PVDD2: CA99.1 CA100.1 LA2.1 UA2.46
+V1.8S_EDRAM: R1334.2 RC232.1 UCPU1.H63
+VBUS_DC_SS: PD302.2 PQ211.1 PQ211.2 PQ211.5 PQ211.6 PQ211.7 PQ212.1 PQ212.2 PQ212.5 PQ212.6 PQ212.7 PR267.1
+VCC0V9_CIO: CT101.1 CT102.1 CT103.1 UT1.R8 UT1.R9 UT1.R11 UT1.R12
+VCC0V9_DP: CT62.1 CT63.1 CT64.1 CT65.1 CT66.1 CT67.1 CT68.1 UT1.L6 UT1.L8 UT1.L11 UT1.L12 UT1.M6 UT1.M8 UT1.T11 UT1.T12 UT1.V11 UT1.V12 UT1.V13
+VCC0V9_PCIE: CT71.1 CT72.1 CT80.1 CT81.1 UT1.L18 UT1.L19 UT1.M13 UT1.M15 UT1.M16 UT1.M18 UT1.N18 UT1.N19
+VCC0V9_USB: CT93.1 CT94.1 UT1.R15 UT1.R16
+VCC_CORE: PC1200.1 PC1201.1 PC1202.1 PC1203.1 PC1204.1 PC1205.1 PC1206.1 PC1207.1 PC1208.1 PC1209.1 PC1210.1 PC1211.1 PC1212.1 PC1213.1 PC1214.1 PC1215.1 PC1216.1 PC1230.1 PC1231.1 PC1232.1 PC1233.1 PC1234.1 PC1235.1 PC1236.1 PC1237.1 PC1238.1 PC1239.1 PC1240.1 PC1241.1 PC1242.1 PC1243.1 PC1244.1 PC1245.1 PC1259.1 PC1260.1 PC1261.1 PC1262.1 PC1263.1 PC1264.1 PC1265.1 PC1266.1 PC1267.1 PC1268.1 PC1269.1 PC1270.1 PC1271.1 PC1272.1 PC1273.1 PC1274.1 PC1275.1 PC1288.1 PC1289.1 PC1290.1 PC1291.1 PC1292.1 PC1293.1 PC1294.1 PC1295.1 PC1296.1 PC1297.1 PC1298.1 PC1299.1 PC1300.1 PC1301.1 PC1302.1 PC1303.1 PC1304.1 PC1305.1 PC1308.1 PC1309.1 PL1100.2 PR1131.1 RC140.1 UCPU1.A30 UCPU1.A34 UCPU1.A39 UCPU1.A44 UCPU1.AK33 UCPU1.AK35 UCPU1.AK37 UCPU1.AK38 UCPU1.AK40 UCPU1.AL33 UCPU1.AL37 UCPU1.AL40 UCPU1.AM32 UCPU1.AM33 UCPU1.AM35 UCPU1.AM37 UCPU1.AM38 UCPU1.G30 UCPU1.G32 UCPU1.G33 UCPU1.G35 UCPU1.G37 UCPU1.G38 UCPU1.G40 UCPU1.G42 UCPU1.J30 UCPU1.J33 UCPU1.J37 UCPU1.J40 UCPU1.K33 UCPU1.K35 UCPU1.K37 UCPU1.K38 UCPU1.K40 UCPU1.K42 UCPU1.K43
+VCC_CORE_G0: T122.1(TP-1) UCPU1.K32
+VCC_CORE_G1: T123.1(TP-1) UCPU1.AK32
+VCC_EDRAM: CC180.1 CC183.1 CC188.1 CC189.1 CC190.1 CC191.1 CC192.1 PR1528.2 UCPU1.AB62 UCPU1.P62 UCPU1.V62
+VCC_EDRAM_P: PC1503.1 PC1504.1 PC1505.1 PL1501.2 PR1506.1 PR1528.1 PU1500.1
+VCC_EOPIO: CC184.1 CC187.1 PR1529.2 UCPU1.AE62 UCPU1.AG62
+VCC_EOPIO_P: PC1506.1 PC1515.1 PC1516.1 PL1503.2 PR1519.1 PR1529.1 PU1501.1
+VCC_GT: PC1217.1 PC1218.1 PC1219.1 PC1220.1 PC1221.1 PC1222.1 PC1223.1 PC1224.1 PC1225.1 PC1226.1 PC1227.1 PC1228.1 PC1229.1 PC1246.1 PC1247.1 PC1248.1 PC1249.1 PC1250.1 PC1251.1 PC1252.1 PC1253.1 PC1254.1 PC1255.1 PC1256.1 PC1257.1 PC1258.1 PC1276.1 PC1277.1 PC1278.1 PC1279.1 PC1280.1 PC1281.1 PC1282.1 PC1283.1 PC1284.1 PC1285.1 PC1286.1 PC1287.1 PC1306.1 PC1307.1 PC1329.1 PC1330.1 PC1331.1 PC1332.1 PC1333.1 PC1334.1 PC1335.1 PC1336.1 PC1337.1 PC1338.1 PC1339.1 PC1340.1 PC1341.1 PC1342.1 PC1343.1 PC1344.1 PC1345.1 PC1346.1 PC1347.1 PC1348.1 PC1349.1 PC1350.1 PC1351.1 PC1352.1 PC1353.1 PC1354.1 PC1355.1 PL1101.2 PL1102.2 PR1133.1 PR1135.1 RC161.1 UCPU1.A48 UCPU1.A53 UCPU1.A58 UCPU1.A62 UCPU1.A66 UCPU1.AA63 UCPU1.AA64 UCPU1.AA66 UCPU1.AA67 UCPU1.AA69 UCPU1.AA70 UCPU1.AA71 UCPU1.AC64 UCPU1.AC65 UCPU1.AC66 UCPU1.AC67 UCPU1.AC68 UCPU1.AC69 UCPU1.AC70 UCPU1.AC71 UCPU1.AK42 UCPU1.AK43 UCPU1.AK45 UCPU1.AK46 UCPU1.AK48 UCPU1.AK50 UCPU1.AK52 UCPU1.AK53 UCPU1.AK55 UCPU1.AK56 UCPU1.AK58 UCPU1.AK60 UCPU1.AK70 UCPU1.AL43 UCPU1.AL46 UCPU1.AL50 UCPU1.AL53 UCPU1.AL56 UCPU1.AL60 UCPU1.AM48 UCPU1.AM50 UCPU1.AM52 UCPU1.AM53 UCPU1.AM56 UCPU1.AM58 UCPU1.AU58 UCPU1.AU63 UCPU1.BB57 UCPU1.BB66 UCPU1.J43 UCPU1.J45 UCPU1.J46 UCPU1.J48 UCPU1.J50 UCPU1.J52 UCPU1.J53 UCPU1.J55 UCPU1.J56 UCPU1.J58 UCPU1.J60 UCPU1.K48 UCPU1.K50 UCPU1.K52 UCPU1.K53 UCPU1.K55 UCPU1.K56 UCPU1.K58 UCPU1.K60 UCPU1.L62 UCPU1.L63 UCPU1.L64 UCPU1.L65 UCPU1.L66 UCPU1.L67 UCPU1.L68 UCPU1.L69 UCPU1.L70 UCPU1.L71 UCPU1.M62 UCPU1.N63 UCPU1.N64 UCPU1.N66 UCPU1.N67 UCPU1.N69 UCPU1.N70 UCPU1.N71 UCPU1.R63 UCPU1.R64 UCPU1.R65 UCPU1.R66 UCPU1.R67 UCPU1.R68 UCPU1.R69 UCPU1.R70 UCPU1.R71 UCPU1.T62 UCPU1.U65 UCPU1.U68 UCPU1.U71 UCPU1.W63 UCPU1.W64 UCPU1.W65 UCPU1.W66 UCPU1.W67 UCPU1.W68 UCPU1.W69 UCPU1.W70 UCPU1.W71 UCPU1.Y62
+VCC_SA: PC1310.1 PC1311.1 PC1312.1 PC1313.1 PC1314.1 PC1315.1 PC1316.1 PC1317.1 PC1318.1 PC1319.1 PC1320.1 PC1321.1 PC1322.1 PC1323.1 PC1324.1 PC1325.1 PC1326.1 PC1327.1 PC1328.1 PL1005.2 PR1137.1 RC168.1 UCPU1.AK23 UCPU1.AK25 UCPU1.G23 UCPU1.G25 UCPU1.G27 UCPU1.G28 UCPU1.J22 UCPU1.J23 UCPU1.J27 UCPU1.K23 UCPU1.K25 UCPU1.K27 UCPU1.K28 UCPU1.K30
+VCCPLL_OC: CC261.1 CZ83.1 R1333.2 UCPU1.AL23
AGND: CA28.2 CA29.1 CA40.2 CA68.1 CA69.2 CA74.2 CA80.2 CA82.2 CA87.2 CA101.2 CA102.2 CA103.2 CA107.1 CA109.2 CA110.1 JPA1.1 JPA2.1 JPA3.1 QA1.1 QA1.4 QA3.1 QA3.4 QA6.3 QA9.3 RA20.2 RA30.2 RA35.2 RA60.2 RA61.2 RA77.2 UA2.25 UA2.38
GND: C2.2 C3.2 C4.2 C5.2 C6.2 C7.2 C8.2 C94.2 C95.2 C96.2 C97.2 C98.2 C135.2 C265.2 C303.2 C352.2 C355.2 C375.2 C376.2 C377.2 C397.1 C398.1 C401.1 C402.1 C612.2 C614.2 C615.2 C616.2 C617.2 C618.2 C712.2 C713.2 C715.2 C716.2 C719.2 C720.2 C721.2 C722.2 C962.2 C963.2 C1102.1 C1143.2 C1145.2 C1158.2 C1159.2 C1160.2 C1161.2 C1162.2 C1163.2 C1164.2 C1166.2 C1167.2 C1168.2 C1169.2 C1199.2 C1200.2 C1201.2 C1203.2 C1204.2 C1205.2 C1208.2 C1211.2 C1212.2 C1213.2 C1214.2 C1215.2 C1216.2 C1217.2 C1218.2 C1220.2 C1221.2 C1222.2 C1223.2 C1225.2 C1226.2 C1229.2 C1254.2 C1256.2 C1257.2 C1258.2 C1264.2 C1273.2 C1274.2 C1275.2 C1278.2 C1279.2 C1280.2 C1289.2 C1292.2 C1293.2 C1297.2 C1298.2 C1301.2 C1302.2 C1304.2 C1309.2 C1321.2 C1322.2 C1324.2 C1325.2 C1339.2 C1341.2 C1345.2 C1346.2 C1347.2 C1348.2 C1349.2 C1350.2 C1353.2 C1354.2 C2973.2 C2982.2 C2983.2 CA2.2 CA3.2 CA4.2 CA5.2 CA6.2 CA7.2 CA23.1 CA24.1 CA25.1 CA27.1 CA30.1 CA31.2 CA32.2 CA33.2 CA35.2 CA42.2 CA53.1 CA54.1 CA55.1 CA56.1 CA72.2 CA78.2 CA83.2 CA97.2 CA98.2 CA99.2 CA100.2 CA104.2 CA105.2 CA106.2 CA108.1 CA111.2 CA112.2 CC4.1 CC5.1 CC8.1 CC10.2 CC21.2 CC22.2 CC23.2 CC24.2 CC25.2 CC26.2 CC27.2 CC28.2 CC29.2 CC31.2 CC32.2 CC33.2 CC34.2 CC35.2 CC125.2 CC174.2 CC175.2 CC176.2 CC177.2 CC178.2 CC179.2 CC180.2 CC181.2 CC182.2 CC183.2 CC184.2 CC185.2 CC186.2 CC187.2 CC188.2 CC189.2 CC190.2 CC191.2 CC192.2 CC194.2 CC195.2 CC199.2 CC202.2 CC203.2 CC204.2 CC205.2 CC206.2 CC209.2 CC210.2 CC211.2 CC212.2 CC213.2 CC214.2 CC217.2 CC218.2 CC220.2 CC223.2 CC224.2 CC225.2 CC240.2 CC248.2 CC249.2 CC250.2 CC251.2 CC252.2 CC253.2 CC256.2 CC257.2 CC258.2 CC259.2 CC260.2 CC261.2 CC264.2 CC265.2 CC266.2 CC267.2 CC268.2 CC269.2 CC270.2 CC271.2 CC272.2 CC273.2 CC274.2 CC279.2 CC280.2 CD1.2 CD2.2 CD3.2 CD4.2 CD5.2 CD6.2 CD7.2 CD8.2 CD29.2 CD30.2 CD33.2 CD34.2 CD37.2 CD38.2 CD41.2 CD42.2 CD57.2 CD58.2 CD59.2 CD60.2 CD61.2 CD62.2 CD63.2 CD64.2 CD85.2 CD86.2 CD87.2 CD88.2 CD89.2 CD90.2 CD91.2 CD92.2 CD117.2 CD118.2 CD119.2 CD120.2 CD129.2 CD132.2 CD133.2 CD135.2 CD136.2 CD139.2 CD140.2 CD142.2 CD143.2 CD144.2 CD145.2 CD146.2 CD147.2 CD148.2 CD149.2 CD150.2 CD151.2 CD152.2 CD153.2 CD154.2 CD155.2 CD156.2 CD157.2 CD158.2 CD159.2 CD160.2 CD161.2 CD162.2 CD163.2 CD164.2 CD165.2 CD166.2 CD167.2 CD168.2 CD169.2 CD170.2 CD171.2 CD172.2 CD173.2 CD174.2 CD175.2 CD176.2 CD177.2 CD178.2 CD179.2 CD180.2 CD181.2 CD182.2 CD183.2 CD184.2 CD196.2 CD197.2 CE3.2 CE4.2 CE10.2 CE13.2 CE14.2 CE17.2 CE21.2 CE22.2 CE38.2 CE40.2 CE41.2 CE42.2 CE43.2 CE45.2 CE46.2 CE49.2 CE50.2 CE52.2 CE53.2 CE54.2 CE55.2 CE56.2 CE59.2 CE61.2 CE62.2 CE63.2 CE64.2 CE65.2 CE68.2 CH95.2 CMOS1.2 CS44.2 CT9.2 CT43.2 CT44.2 CT47.2 CT50.2 CT52.2 CT53.2 CT54.2 CT55.2 CT56.2 CT57.2 CT62.2 CT63.2 CT64.2 CT65.2 CT66.2 CT67.2 CT68.2 CT71.2 CT72.2 CT74.2 CT80.2 CT81.2 CT83.2 CT84.2 CT85.2 CT86.2 CT88.2 CT89.2 CT90.2 CT91.2 CT92.2 CT93.2 CT94.2 CT95.2 CT96.2 CT97.2 CT98.2 CT99.2 CT100.2 CT101.2 CT102.2 CT103.2 CT144.2 CT151.2 CT152.2 CT163.2 CT164.2 CT165.2 CZ78.2 CZ82.2 CZ83.2 CZ84.2 CZ85.2 CZ86.2 CZ87.2 CZ89.2 CZ90.2 CZ91.2 CZ92.2 D75.2 D76.2 D77.2 D78.2 D79.2 D80.2 D82.2 D83.2 D84.2 D85.2 D86.2 D87.2 D88.2 D89.2 D90.2 D91.2 D123.2 DA1.1 DA2.1 DA3.1 DA4.1 DA5.2 DA7.2 DI1.3 DI1.8 DI2.1 DI3.1 DI4.1 DI7.1 H1.1(TP-1) H4.1(TP-1) H6.1(TP-1) H7.1(TP-1) H9.1(TP-1) H10.1(TP-1) H11.1(TP-1) H12.1(TP-1) H13.1(TP-1) H14.1(TP-1) H15.1(TP-1) H16.1(TP-1) H17.1(TP-1) H18.1(TP-1) H19.1(TP-1) H20.1 H21.1 H22.1 H24.1 H25.1 JAPS1.8 JAPS1.10 JAPS1.12 JAPS1.14 JAPS1.19 JAPS1.20 JAR1.5 JAR1.6 JBATT1.6 JBATT1.7 JBATT1.8 JBATT1.9 JBATT1.10 JBATT1.11 JCAM.3 JCAM.6 JCAM.7 JCAM.8 JDEG1.10 JDEG1.11 JDEG1.12 JEDP.10 JEDP.11 JEDP.12 JEDP.13 JEDP.15 JEDP.16 JEDP.17 JEDP.18 JEDP.27 JEDP.30 JEDP.33 JEDP.36 JEDP.41 JEDP.42 JEDP.43 JEDP.44 JEDP.45 JFAN1.1 JFAN1.5 JFAN1.6 JHP1.7 JIO1.1 JIO1.5 JIO1.6 JIO1.7 JIO1.11 JIO1.12 JIO1.13 JIO1.15 JIO1.17 JIO1.19 JIO1.21 JIO1.23 JIO1.25 JIO1.27 JIO1.29 JIO1.31 JIO1.33 JIO1.62 JIO1.63 JKB1.13 JKB1.14 JKB1.15 JKB1.16 JKB1.17 JLPDE1.9 JLPDE1.11 JLPDE1.12 JNGFF1.1 JNGFF1.7 JNGFF1.10 JNGFF1.15 JNGFF1.16 JNGFF1.21 JNGFF1.22 JNGFF1.25 JNGFF1.28 JNGFF1.31 JNGFF1.37 JNGFF1.43 JNGFF1.49 JNGFF1.55 JNGFF1.61 JNGFF1.67 JNGFF1.68 JNGFF1.69 JNGFF2.1 JNGFF2.3 JNGFF2.9 JNGFF2.15 JNGFF2.21 JNGFF2.27 JNGFF2.33 JNGFF2.39 JNGFF2.45 JNGFF2.51 JNGFF2.57 JNGFF2.63 JNGFF2.65 JNGFF2.67 JNGFF2.68 JNGFF2.69 JP100.6 JP100.7 JPA1.2 JPA2.2 JPA3.2 JRTC1.2 JRTC1.3 JRTC1.4 JSPI1.18 JSPI1.19 JSPI1.20 JSPI1.21 JSPI1.22 JSPK1.5 JSPK1.6 JTAG1.2 JTP1.4 JTP1.9 JTP1.10 JTS.1 JTS.4 JTS.7 JTS.8 JUART.4 JUART.5 JUART.6 JUSB2.4 JUSB2.7 JUSB2.10 JUSB2.11 JUSB2.12 JUSB2.13 JUSBC1.1 JUSBC1.2 JUSBC1.3 JUSBC1.4 JUSBC1.A1 JUSBC1.A12 JUSBC1.B1 JUSBC1.B12 JXDP1.2 JXDP1.7 JXDP1.8 JXDP1.13 JXDP1.14 JXDP1.19 JXDP1.20 JXDP1.25 JXDP1.26 JXDP1.31 JXDP1.32 JXDP1.37 JXDP1.38 JXDP1.49 JXDP1.50 JXDP1.59 MC3.2 MD9.1 MD10.1 PC100.2 PC101.2 PC102.1 PC103.2 PC106.2 PC107.2 PC108.2 PC203.2 PC204.2 PC205.2 PC209.2 PC210.2 PC211.2 PC212.2 PC213.2 PC214.2 PC215.2 PC216.2 PC217.2 PC301.2 PC302.2 PC303.2 PC304.2 PC305.2 PC306.2 PC307.2 PC312.2 PC313.1 PC314.2 PC315.2 PC316.2 PC317.2 PC319.2 PC320.2 PC321.2 PC323.2 PC324.2 PC325.2 PC326.2 PC327.2 PC328.2 PC329.2 PC333.2 PC400.2 PC401.2 PC402.2 PC403.2 PC405.2 PC406.2 PC407.2 PC500.2 PC501.2 PC502.2 PC503.2 PC505.2 PC506.2 PC507.2 PC508.2 PC509.2 PC510.2 PC513.2 PC514.2 PC515.2 PC516.2 PC517.2 PC518.2 PC519.2 PC520.2 PC521.2 PC522.2 PC523.2 PC524.2 PC526.2 PC527.2 PC528.2 PC529.2 PC600.2 PC601.2 PC602.2 PC603.2 PC604.2 PC606.2 PC607.2 PC608.2 PC610.2 PC611.2 PC612.2 PC613.2 PC614.2 PC615.2 PC616.2 PC617.2 PC618.2 PC700.2 PC701.2 PC702.2 PC704.2 PC705.2 PC706.2 PC708.2 PC709.2 PC710.2 PC711.2 PC712.2 PC713.2 PC800.2 PC802.2 PC803.2 PC804.2 PC805.2 PC806.2 PC807.2 PC900.2 PC902.2 PC903.2 PC904.2 PC905.2 PC906.2 PC907.2 PC1004.2 PC1005.2 PC1006.1 PC1007.2 PC1019.1 PC1020.1 PC1021.1 PC1056.1 PC1064.1 PC1065.1 PC1066.2 PC1073.2 PC1074.2 PC1076.2 PC1079.2 PC1080.2 PC1081.2 PC1083.2 PC1084.2 PC1086.2 PC1087.2 PC1089.2 PC1091.2 PC1093.2 PC1095.1 PC1096.2 PC1097.2 PC1098.1 PC1099.1 PC1100.2 PC1101.2 PC1102.2 PC1103.2 PC1104.2 PC1105.2 PC1107.2 PC1108.2 PC1109.2 PC1110.2 PC1111.2 PC1112.2 PC1113.2 PC1114.2 PC1115.2 PC1117.2 PC1118.2 PC1119.2 PC1120.2 PC1121.2 PC1122.2 PC1123.2 PC1124.2 PC1125.2 PC1127.2 PC1128.2 PC1129.2 PC1130.2 PC1131.1 PC1132.1 PC1134.2 PC1135.2 PC1200.2 PC1201.2 PC1202.2 PC1203.2 PC1204.2 PC1205.2 PC1206.2 PC1207.2 PC1208.2 PC1209.2 PC1210.2 PC1211.2 PC1212.2 PC1213.2 PC1214.2 PC1215.2 PC1216.2 PC1217.2 PC1218.2 PC1219.2 PC1220.2 PC1221.2 PC1222.2 PC1223.2 PC1224.2 PC1225.2 PC1226.2 PC1227.2 PC1228.2 PC1229.2 PC1230.2 PC1231.2 PC1232.2 PC1233.2 PC1234.2 PC1235.2 PC1236.2 PC1237.2 PC1238.2 PC1239.2 PC1240.2 PC1241.2 PC1242.2 PC1243.2 PC1244.2 PC1245.2 PC1246.2 PC1247.2 PC1248.2 PC1249.2 PC1250.2 PC1251.2 PC1252.2 PC1253.2 PC1254.2 PC1255.2 PC1256.2 PC1257.2 PC1258.2 PC1259.2 PC1260.2 PC1261.2 PC1262.2 PC1263.2 PC1264.2 PC1265.2 PC1266.2 PC1267.2 PC1268.2 PC1269.2 PC1270.2 PC1271.2 PC1272.2 PC1273.2 PC1274.2 PC1275.2 PC1276.2 PC1277.2 PC1278.2 PC1279.2 PC1280.2 PC1281.2 PC1282.2 PC1283.2 PC1284.2 PC1285.2 PC1286.2 PC1287.2 PC1288.2 PC1289.2 PC1290.2 PC1291.2 PC1292.2 PC1293.2 PC1294.2 PC1295.2 PC1296.2 PC1297.2 PC1298.2 PC1299.2 PC1300.2 PC1301.2 PC1302.2 PC1303.2 PC1304.2 PC1305.2 PC1306.2 PC1307.2 PC1308.2 PC1309.2 PC1310.2 PC1311.2 PC1312.2 PC1313.2 PC1314.2 PC1315.2 PC1316.2 PC1317.2 PC1318.2 PC1319.2 PC1320.2 PC1321.2 PC1322.2 PC1323.2 PC1324.2 PC1325.2 PC1326.2 PC1327.2 PC1328.2 PC1329.2 PC1330.2 PC1331.2 PC1332.2 PC1333.2 PC1334.2 PC1335.2 PC1336.2 PC1337.2 PC1338.2 PC1339.2 PC1340.2 PC1341.2 PC1342.2 PC1343.2 PC1344.2 PC1345.2 PC1346.2 PC1347.2 PC1348.2 PC1349.2 PC1350.2 PC1351.2 PC1352.2 PC1353.2 PC1354.2 PC1355.2 PC1400.2 PC1401.2 PC1402.2 PC1403.2 PC1404.2 PC1405.2 PC1406.2 PC1408.2 PC1409.2 PC1410.2 PC1411.2 PC1412.2 PC1413.2 PC1414.2 PC1415.2 PC1416.2 PC1417.2 PC1418.2 PC1419.2 PC1420.2 PC1500.2 PC1501.2 PC1502.2 PC1503.2 PC1504.2 PC1505.2 PC1506.2 PC1508.2 PC1509.2 PC1510.2 PC1511.2 PC1512.2 PC1513.2 PC1514.2 PC1515.2 PC1516.2 PC1517.2 PC1518.2 PC1519.2 PC1520.2 PD100.1 PD101.1 PD102.2 PH1007.1 PH1008.1 PJP300.2 PL104.2 PQ101.3 PQ206.1 PQ206.4 PQ207.1 PQ207.4 PQ208.4 PQ209.1 PQ209.4 PQ215.1 PQ216.1 PQ217.1 PQ217.4 PQ218.1 PQ218.4 PQ219.1 PQ219.4 PQ220.3 PQ223.1 PQ223.4 PQ224.3 PQ304.1 PQ304.2 PQ304.3 PQ400.4 PQ1302.5 PQ1302.6 PQ1302.7 PR106.2 PR107.2 PR215.2 PR219.2 PR230.2 PR246.2 PR247.2 PR268.2 PR269.2 PR270.2 PR271.2 PR272.2 PR273.2 PR282.2 PR283.2 PR290.2 PR301.2 PR406.2 PR407.2 PR412.2 PR413.2 PR509.2 PR605.2 PR606.2 PR608.2 PR610.2 PR701.2 PR707.2 PR709.2 PR804.2 PR904.2 PR1067.1 PR1069.2 PR1071.1 PR1094.2 PR1099.1 PR1104.2 PR1108.2 PR1117.2 PR1121.2 PR1126.1 PR1402.2 PR1406.2 PR1407.2 PR1413.2 PR1417.2 PR1418.2 PR1422.2 PR1425.2 PR1502.2 PR1507.2 PR1508.2 PR1513.2 PR1517.2 PR1518.2 PR1526.2 PR1527.2 PU200.1 PU200.2 PU201.4 PU202.2 PU203.4 PU300.22 PU400.4 PU401.3 PU402.3 PU500.7 PU500.8 PU500.18 PU500.21 PU501.7 PU501.8 PU501.18 PU501.21 PU600.4 PU600.9 PU600.15 PU700.9 PU800.6 PU800.8 PU800.15 PU800.16 PU800.17 PU900.6 PU900.8 PU900.15 PU900.16 PU900.17 PU1000.41 PU1100.3 PU1100.9 PU1101.3 PU1101.9 PU1102.3 PU1102.9 PU1305.4 PU1305.9 PU1400.15 PU1400.16 PU1400.17 PU1401.6 PU1401.15 PU1401.16 PU1401.17 PU1500.15 PU1500.16 PU1500.17 PU1501.15 PU1501.16 PU1501.17 Q71.3 QE12.1 QE12.4 QE13.1 QE13.4 QE14.1 QE14.4 R7.2 R60.2 R290.1 R540.2 R545.2 R1027.1 R1140.2 R1161.2 R1162.2 R1175.1 R1176.2 R1186.1 R1187.1 R1188.1 R1216.2 R1403.2 R1405.2 R1468.2 R1472.1 R1473.2 RA41.2 RC1.1 RC3.2 RC4.2 RC5.2 RC6.2 RC7.2 RC19.2 RC20.2 RC44.2 RC48.2 RC65.2 RC75.1 RC85.1 RC86.1 RC88.2 RC89.2 RC90.2 RC91.2 RC96.2 RC109.1 RC110.1 RC112.1 RC113.1 RC114.2 RC122.2 RC136.1 RC139.1 RC141.2 RC163.2 RC166.2 RC167.2 RC219.1 RC220.2 RC227.2 RC242.1 RC293.1 RC312.1 RD19.2 RD25.2 RD26.2 RD51.2 RD52.2 RD53.2 RD54.2 RD55.2 RD56.2 RD57.2 RD58.2 RD112.2 RD115.2 RD116.2 RE2.1 RE22.1 RE23.1 RE54.1 RE58.1 RE59.2 RE63.2 RE66.2 RE68.2 RE77.2 RE78.2 RE82.1 RE85.2 RE89.2 RE90.2 RE91.2 RE97.2 RE99.2 RE101.2 RE103.2 RH56.1 RH129.1 RH139.1 RH145.1 RH146.1 RH147.1 RH153.2 RH442.2 RH443.2 RH556.2 RH557.2 RT1.1 RT2.1 RT3.1 RT4.1 RT5.2 RT12.2 RT37.1 RT38.1 RT39.1 RT40.1 RT43.1 RT44.1 RT45.1 RT48.1 RT49.1 RT50.1 RT164.1 RT187.2 RT188.2 RT190.2 RT200.2 RZ75.2 SW1.4 SW1.5 SW2.1 SW2.3 SW3.3 SW3.4 U15.9 U15.16 U15.23 U15.32 U15.33 U18.4 U48.4 U664.11 U664.15 U683.3 U699.3 U716.11 U716.15 U717.11 U717.15 U719.11 U719.15 U720.11 U720.15 U722.A1 U722.B8 U722.D6 U722.D8 U722.E5 U722.E6 U722.E7 U722.E8 U722.F5 U722.F6 U722.F7 U722.F8 U722.G5 U722.G6 U722.G7 U722.G8 U722.H4 U722.H5 U722.H8 U722.L1 U722.L11 U728.2 U729.3 UA2.49 UC2.3 UC7.3 UC8.3 UC9.3 UC10.3 UC11.3 UC12.3 UC13.3 UCPU1.A5 UCPU1.A67 UCPU1.A70 UCPU1.AA2 UCPU1.AA4 UCPU1.AA65 UCPU1.AA68 UCPU1.AB8 UCPU1.AB15 UCPU1.AB16 UCPU1.AB18 UCPU1.AB21 UCPU1.AD8 UCPU1.AD13 UCPU1.AD16 UCPU1.AD19 UCPU1.AD20 UCPU1.AD21 UCPU1.AD62 UCPU1.AE64 UCPU1.AE65 UCPU1.AE66 UCPU1.AE67 UCPU1.AE68 UCPU1.AE69 UCPU1.AF1 UCPU1.AF2 UCPU1.AF4 UCPU1.AF10 UCPU1.AF15 UCPU1.AF17 UCPU1.AF63 UCPU1.AG16 UCPU1.AG17 UCPU1.AG18 UCPU1.AG19 UCPU1.AG20 UCPU1.AG21 UCPU1.AG71 UCPU1.AH6 UCPU1.AH13 UCPU1.AH63 UCPU1.AH64 UCPU1.AH67 UCPU1.AJ4 UCPU1.AJ15 UCPU1.AJ18 UCPU1.AJ20 UCPU1.AK8 UCPU1.AK11 UCPU1.AK16 UCPU1.AK18 UCPU1.AK21 UCPU1.AK22 UCPU1.AK27 UCPU1.AK63 UCPU1.AK68 UCPU1.AK69 UCPU1.AL2 UCPU1.AL4 UCPU1.AL28 UCPU1.AL32 UCPU1.AL35 UCPU1.AL38 UCPU1.AL45 UCPU1.AL48 UCPU1.AL52 UCPU1.AL55 UCPU1.AL58 UCPU1.AL64 UCPU1.AL65 UCPU1.AL66 UCPU1.AM8 UCPU1.AM13 UCPU1.AM21 UCPU1.AM25 UCPU1.AM27 UCPU1.AM43 UCPU1.AM45 UCPU1.AM46 UCPU1.AM55 UCPU1.AM60 UCPU1.AM61 UCPU1.AM68 UCPU1.AM71 UCPU1.AN20 UCPU1.AN23 UCPU1.AN28 UCPU1.AN30 UCPU1.AN32 UCPU1.AN33 UCPU1.AN35 UCPU1.AN37 UCPU1.AN38 UCPU1.AN40 UCPU1.AN42 UCPU1.AN58 UCPU1.AN63 UCPU1.AP10 UCPU1.AP18 UCPU1.AP20 UCPU1.AP23 UCPU1.AP28 UCPU1.AP32 UCPU1.AP35 UCPU1.AP38 UCPU1.AP42 UCPU1.AP58 UCPU1.AP63 UCPU1.AP68 UCPU1.AP70 UCPU1.AR5 UCPU1.AR8 UCPU1.AR11 UCPU1.AR15 UCPU1.AR16 UCPU1.AR20 UCPU1.AR23 UCPU1.AR28 UCPU1.AR35 UCPU1.AR42 UCPU1.AR43 UCPU1.AR45 UCPU1.AR46 UCPU1.AR48 UCPU1.AR50 UCPU1.AR52 UCPU1.AR53 UCPU1.AR55 UCPU1.AR58 UCPU1.AR63 UCPU1.AT2 UCPU1.AT4 UCPU1.AT20 UCPU1.AT23 UCPU1.AT28 UCPU1.AT35 UCPU1.AT42 UCPU1.AT56 UCPU1.AT58 UCPU1.AT63 UCPU1.AT68 UCPU1.AT71 UCPU1.AU10 UCPU1.AU15 UCPU1.AU20 UCPU1.AU32 UCPU1.AU38 UCPU1.AV1 UCPU1.AV68 UCPU1.AV69 UCPU1.AV70 UCPU1.AV71 UCPU1.AW6 UCPU1.AW8 UCPU1.AW10 UCPU1.AW12 UCPU1.AW14 UCPU1.AW16 UCPU1.AW18 UCPU1.AW21 UCPU1.AW23 UCPU1.AW26 UCPU1.AW28 UCPU1.AW30 UCPU1.AW32 UCPU1.AW34 UCPU1.AW36 UCPU1.AW38 UCPU1.AW41 UCPU1.AW43 UCPU1.AW45 UCPU1.AW47 UCPU1.AW49 UCPU1.AW51 UCPU1.AW53 UCPU1.AW55 UCPU1.AW57 UCPU1.AW60 UCPU1.AW62 UCPU1.AW64 UCPU1.AW66 UCPU1.AY3 UCPU1.AY66 UCPU1.AY71 UCPU1.B10 UCPU1.B14 UCPU1.B18 UCPU1.B22 UCPU1.B30 UCPU1.B34 UCPU1.B39 UCPU1.B44 UCPU1.B48 UCPU1.B53 UCPU1.B58 UCPU1.B62 UCPU1.B66 UCPU1.B71 UCPU1.BA1 UCPU1.BA2 UCPU1.BA6 UCPU1.BA10 UCPU1.BA14 UCPU1.BA18 UCPU1.BA23 UCPU1.BA28 UCPU1.BA32 UCPU1.BA36 UCPU1.BA41 UCPU1.BA45 UCPU1.BA49 UCPU1.BA53 UCPU1.BA57 UCPU1.BA62 UCPU1.BA66 UCPU1.BA71 UCPU1.BB6 UCPU1.BB18 UCPU1.BB26 UCPU1.BB30 UCPU1.BB34 UCPU1.BB38 UCPU1.BB43 UCPU1.BB55 UCPU1.BB60 UCPU1.BB64 UCPU1.BB67 UCPU1.BB70 UCPU1.C1 UCPU1.C5 UCPU1.C25 UCPU1.D6 UCPU1.D10 UCPU1.D11 UCPU1.D14 UCPU1.D18 UCPU1.D22 UCPU1.D25 UCPU1.D26 UCPU1.D30 UCPU1.D34 UCPU1.D39 UCPU1.D44 UCPU1.D45 UCPU1.D47 UCPU1.D48 UCPU1.D53 UCPU1.D58 UCPU1.D62 UCPU1.D66 UCPU1.D69 UCPU1.E6 UCPU1.E11 UCPU1.E15 UCPU1.E18 UCPU1.E21 UCPU1.E46 UCPU1.E50 UCPU1.E53 UCPU1.E56 UCPU1.E65 UCPU1.E71 UCPU1.F1 UCPU1.F2 UCPU1.F4 UCPU1.F8 UCPU1.F13 UCPU1.F22 UCPU1.F23 UCPU1.F27 UCPU1.F28 UCPU1.F32 UCPU1.F33 UCPU1.F35 UCPU1.F37 UCPU1.F38 UCPU1.F40 UCPU1.F42 UCPU1.F68 UCPU1.G5 UCPU1.G6 UCPU1.G10 UCPU1.G22 UCPU1.G43 UCPU1.G45 UCPU1.G48 UCPU1.G52 UCPU1.G55 UCPU1.G58 UCPU1.G60 UCPU1.G63 UCPU1.G66 UCPU1.H15 UCPU1.H18 UCPU1.H71 UCPU1.J8 UCPU1.J11 UCPU1.J13 UCPU1.J25 UCPU1.J28 UCPU1.J32 UCPU1.J35 UCPU1.J38 UCPU1.J42 UCPU1.K16 UCPU1.K18 UCPU1.K22 UCPU1.K61 UCPU1.K63 UCPU1.K64 UCPU1.K65 UCPU1.K66 UCPU1.K67 UCPU1.K68 UCPU1.K70 UCPU1.K71 UCPU1.L2 UCPU1.L4 UCPU1.L8 UCPU1.L11 UCPU1.L16 UCPU1.L17 UCPU1.L18 UCPU1.L20 UCPU1.N6 UCPU1.N10 UCPU1.N13 UCPU1.N19 UCPU1.N21 UCPU1.N65 UCPU1.N68 UCPU1.P17 UCPU1.P19 UCPU1.P20 UCPU1.P21 UCPU1.R6 UCPU1.R13 UCPU1.T2 UCPU1.T4 UCPU1.T15 UCPU1.T17 UCPU1.T18 UCPU1.T21 UCPU1.U10 UCPU1.U63 UCPU1.U64 UCPU1.U66 UCPU1.U67 UCPU1.U69 UCPU1.U70 UCPU1.V16 UCPU1.V17 UCPU1.V18 UCPU1.W6 UCPU1.W9 UCPU1.W13 UCPU1.Y17 UCPU1.Y19 UCPU1.Y20 UCPU1.Y21 UD19.B2 UD19.B5 UD19.B6 UD19.B12 UD19.C3 UD19.C5 UD19.C6 UD19.D3 UD19.D8 UD19.D12 UD19.E4 UD19.E5 UD19.E6 UD19.F4 UD19.F5 UD19.F6 UD19.F12 UD19.G3 UD19.G4 UD19.G6 UD19.G8 UD19.G9 UD19.H2 UD19.H10 UD19.J4 UD19.J12 UD19.K2 UD19.K10 UD19.L6 UD19.L8 UD19.L9 UD19.M4 UD19.M5 UD19.M6 UD19.M12 UD19.N4 UD19.N5 UD19.N6 UD19.P3 UD19.P8 UD19.P12 UD19.R4 UD19.R5 UD19.R6 UD19.T2 UD19.T3 UD19.T4 UD19.T5 UD19.T6 UD19.T12 UD20.B2 UD20.B5 UD20.B6 UD20.B12 UD20.C3 UD20.C5 UD20.C6 UD20.D3 UD20.D8 UD20.D12 UD20.E4 UD20.E5 UD20.E6 UD20.F4 UD20.F5 UD20.F6 UD20.F12 UD20.G3 UD20.G4 UD20.G6 UD20.G8 UD20.G9 UD20.H2 UD20.H10 UD20.J4 UD20.J12 UD20.K2 UD20.K10 UD20.L6 UD20.L8 UD20.L9 UD20.M4 UD20.M5 UD20.M6 UD20.M12 UD20.N4 UD20.N5 UD20.N6 UD20.P3 UD20.P8 UD20.P12 UD20.R4 UD20.R5 UD20.R6 UD20.T2 UD20.T3 UD20.T4 UD20.T5 UD20.T6 UD20.T12 UD21.B2 UD21.B5 UD21.B6 UD21.B12 UD21.C3 UD21.C5 UD21.C6 UD21.D3 UD21.D8 UD21.D12 UD21.E4 UD21.E5 UD21.E6 UD21.F4 UD21.F5 UD21.F6 UD21.F12 UD21.G3 UD21.G4 UD21.G6 UD21.G8 UD21.G9 UD21.H2 UD21.H10 UD21.J4 UD21.J12 UD21.K2 UD21.K10 UD21.L6 UD21.L8 UD21.L9 UD21.M4 UD21.M5 UD21.M6 UD21.M12 UD21.N4 UD21.N5 UD21.N6 UD21.P3 UD21.P8 UD21.P12 UD21.R4 UD21.R5 UD21.R6 UD21.T2 UD21.T3 UD21.T4 UD21.T5 UD21.T6 UD21.T12 UD22.B2 UD22.B5 UD22.B6 UD22.B12 UD22.C3 UD22.C5 UD22.C6 UD22.D3 UD22.D8 UD22.D12 UD22.E4 UD22.E5 UD22.E6 UD22.F4 UD22.F5 UD22.F6 UD22.F12 UD22.G3 UD22.G4 UD22.G6 UD22.G8 UD22.G9 UD22.H2 UD22.H10 UD22.J4 UD22.J12 UD22.K2 UD22.K10 UD22.L6 UD22.L8 UD22.L9 UD22.M4 UD22.M5 UD22.M6 UD22.M12 UD22.N4 UD22.N5 UD22.N6 UD22.P3 UD22.P8 UD22.P12 UD22.R4 UD22.R5 UD22.R6 UD22.T2 UD22.T3 UD22.T4 UD22.T5 UD22.T6 UD22.T12 UE4.6 UE5.B11 UE5.B18 UE5.B54 UE5.B60 UE5.B66 UE5.C1 US2.1 UT1.A1 UT1.A6 UT1.A8 UT1.A10 UT1.A12 UT1.A14 UT1.A16 UT1.A18 UT1.A20 UT1.A22 UT1.AA22 UT1.AA23 UT1.AB1 UT1.AB2 UT1.AB6 UT1.AB8 UT1.AB10 UT1.AB12 UT1.AB14 UT1.AB16 UT1.AB18 UT1.AB20 UT1.AB22 UT1.AC1 UT1.AC2 UT1.AC6 UT1.AC8 UT1.AC10 UT1.AC12 UT1.AC14 UT1.AC16 UT1.AC18 UT1.AC20 UT1.AC22 UT1.B1 UT1.B2 UT1.B6 UT1.B8 UT1.B10 UT1.B12 UT1.B14 UT1.B16 UT1.B18 UT1.B20 UT1.B22 UT1.C22 UT1.C23 UT1.D5 UT1.D6 UT1.D8 UT1.D9 UT1.D11 UT1.D12 UT1.D13 UT1.D15 UT1.D16 UT1.D18 UT1.E4 UT1.E5 UT1.E6 UT1.E8 UT1.E9 UT1.E11 UT1.E15 UT1.E16 UT1.E22 UT1.E23 UT1.F5 UT1.F6 UT1.F9 UT1.F16 UT1.F20 UT1.G22 UT1.G23 UT1.H1 UT1.H2 UT1.H5 UT1.H8 UT1.H12 UT1.H13 UT1.H15 UT1.H16 UT1.H20 UT1.J5 UT1.J8 UT1.J12 UT1.J13 UT1.J15 UT1.J18 UT1.J19 UT1.J20 UT1.J22 UT1.J23 UT1.K1 UT1.K2 UT1.L5 UT1.L13 UT1.L15 UT1.L20 UT1.L22 UT1.L23 UT1.M1 UT1.M2 UT1.M5 UT1.M11 UT1.M12 UT1.M19 UT1.M20 UT1.N5 UT1.N8 UT1.N9 UT1.N11 UT1.N12 UT1.N13 UT1.N15 UT1.N20 UT1.N22 UT1.N23 UT1.P1 UT1.P2 UT1.R5 UT1.R18 UT1.R19 UT1.R20 UT1.R22 UT1.R23 UT1.T1 UT1.T2 UT1.T5 UT1.T6 UT1.T8 UT1.T9 UT1.T13 UT1.T15 UT1.T16 UT1.T18 UT1.T20 UT1.U22 UT1.U23 UT1.V5 UT1.V6 UT1.V8 UT1.V9 UT1.V15 UT1.V16 UT1.V20 UT1.W5 UT1.W6 UT1.W8 UT1.W9 UT1.W13 UT1.W18 UT1.W20 UT1.W22 UT1.W23 UT1.Y9 UT1.Y13 UT1.Y20 UT5.4 UT5.9 UT6.4 UT6.9 UZ19.5 UZ22.5 UZ23.5 UZ24.2 UZ25.5 UZ26.5 YC1.2 YC1.4 YT1.2 YT1.4
GNDA_CHG: PC309.1 PC311.2 PC318.1 PC330.2 PC331.2 PC332.2 PC334.1 PC336.2 PC337.2 PJP300.1 PQ302.3 PR310.1 PR317.2 PR322.2 PR327.2 PU300.29
VBUS_ACOK: PC217.1 PQ220.1 PR213.1 PR248.1 PR261.2 PR263.2 PU203.1
VBUS_HV_DIS#: PD206.1 PR274.2 PR287.1 UE5.B2
VBUSSENSE: RC20.1 UCPU1.AG4
VCC0V9_LVR_OUT: CT95.1 CT96.1 CT97.1 CT98.1 UT1.F18 UT1.H11 UT1.H18 UT1.J11
VCC0V9_SVR: CT74.1 CT83.1 CT84.1 CT85.1 CT86.1 CT88.1 CT89.1 CT90.1 CT91.1 CT92.1 LT1.2 UT1.E12 UT1.E13 UT1.F11 UT1.F12 UT1.F13 UT1.F15 UT1.J9 UT1.L9 UT1.M9
VCC1V8A_TBT_LDO: CT151.1 RT201.2 U722.K1
VCC1V8D_TBT_LDO: CT152.1 U722.A2
VCC3V3_TBT_LDO: C1346.1 CT47.1 R1454.1 R1460.1 R1474.1 R1475.1 R1476.1 R1477.1 R1478.1 RT15.1 RT16.1 RT17.1 RT18.1 RT199.2 U722.G1 UT5.8 UT6.8
VCC3V3_TBT_SX: C1345.1 U722.H2
VCC_3V3_PCIE: CT99.1 UT1.L16
VCC_3V3_USB2: CT100.1 UT1.J16
VCC_EDRAM_SENSE: PR1509.2 UCPU1.AC63
VCC_EOPIO_SENSE: PR1520.2 UCPU1.AL63
VCC_GT_SENSE: PC1014.1 PC1022.1 PC1098.2 PR1093.1 RC161.2 UCPU1.J70
VCCIO_SENSE: PR1409.2 RC165.2 UCPU1.AM23
VCCSENSE: PC1090.1 PC1092.1 PC1132.2 PR1079.1 RC140.2 UCPU1.E32
VCCST_EN: RE103.1 UC13.4 UZ25.4
VCCST_PWRGD: RC78.2 UCPU1.B65
VCCSTG_EN: PR1401.1 RZ75.1 RZ76.1 UC9.4 UZ19.4
VIN_1V_PRIM: PC1513.1 PC1514.1 PC1517.1 PC1518.1 PL1502.2 PU1501.10 PU1501.11 PU1501.12
VIN_PRIM: PC1413.1 PC1414.1 PC1417.1 PC1418.1 PL1402.2 PU1401.10 PU1401.11 PU1401.12
VIN_VCC_EDRAM: PC1501.1 PC1502.1 PC1508.1 PC1509.1 PL1500.2 PU1500.10 PU1500.11 PU1500.12
VIN_VCCIO: PC1401.1 PC1402.1 PC1408.1 PC1409.1 PL1400.2 PU1400.10 PU1400.11 PU1400.12
VSS_EDRAM_SENSE: PR1510.2 UCPU1.AE63
VSS_EOPIO_SENSE: PR1521.2 UCPU1.AJ62
VSS_GT_SENSE: PC1019.2 PC1022.2 PU1000.6 RC163.1 UCPU1.J69
VSSIO_SENSE: PR1410.2 RC167.1 UCPU1.AM22
VSSSENSE: PC1092.2 PC1099.2 PU1000.18 RC141.1 UCPU1.E33
+AC_IN: PC206.1 PC207.1 PQ210.4 PQ210.8 PQ211.4 PQ211.8 PQ213.3 PR200.4 PR232.1 PR233.1 PR234.1
+DC_IN: PC106.1 PC107.1 PC108.1 PC201.1 PD204.2 PL103.2 PQ202.4 PQ202.8 PR107.1 PR203.1 PR208.1
+DC_IN_SS: PD301.2 PQ202.1 PQ202.2 PQ202.5 PQ202.6 PQ202.7 PQ203.1 PQ203.2 PQ203.5 PQ203.6 PQ203.7 PR266.1
+DCIN_JACK: JP100.4 JP100.5 PC103.1 PC104.1 PC105.1 PL103.1
+INV_PWR_SRC: C612.1 C2982.1 JEDP.2 JEDP.3 JEDP.4 JEDP.5 Q70.1 Q70.2 Q70.5 Q70.6 R531.2
+LCDVDD: C6.1 C1143.1 C1145.1 C1211.1 JEDP.20 JEDP.21 JEDP.22 JEDP.23 R287.1 R288.1 R289.1 R1322.2
+PBATT: PC100.1 PD300.2 PL100.1 PL101.1 PQ305.5 PQ305.6 PQ305.7 PQ305.8 PR324.2
+PP_HV: C1341.1 PD205.2 PR289.1 U722.A6 U722.A7 U722.A8 U722.B7
+PWR_SRC_AC: PL300.1 PR300.1
+RTC_CELL_VBAT: CE65.1 RE32.2 UE5.B64
+RTCBATT: C2973.1 JRTC1.1 RTCR1.2
+RTCVCC: C1309.1 CC213.1 CC270.1 CH95.1 D122.3 RA16.1 RA54.1 RC56.2 RC57.2 RC69.2 RE31.1 RE32.1 RE36.1 RPE5.5 RPE5.6 UCPU1.AK19 UCPU1.BB14
+SDC_IN: PC202.1 PD300.1 PQ203.4 PQ203.8 PQ205.3 PR204.1 PR205.1 PR206.1 PR223.1 PR231.4 PR300.4 PR306.1
+TPM_LPM: C98.1 CA72.1 RC228.2 RC229.2 U15.8
+V_DDR_REF_CA: CD185.1 RD111.1 UCPU1.AY67
+V_DDR_REFA_R: CD186.1 RD113.1 UCPU1.AY68
+V_DDR_REFB_R: CD187.1 RD114.1 UCPU1.BA67
+VCHGR: PC323.1 PC324.1 PC325.1 PC326.1 PC327.1 PC328.1 PC329.1 PQ305.1 PQ305.2 PQ305.3 PR313.1
+VR_CAP: CE45.1 UE5.B12
+VREFCA: CD180.1 CD181.1 CD183.1 CD184.1 RD17.2 RD19.1 RD111.2 UD19.H4 UD20.H4 UD21.H4 UD22.H4
+VREFDQ_A: CD117.1 CD118.1 RD21.2 RD25.1 RD113.2 UD19.J11 UD20.J11
+VREFDQ_B: CD119.1 CD120.1 RD22.2 RD26.1 RD114.2 UD21.J11 UD22.J11
-DCIN_JACK: JP100.1 JP100.2 PC104.2 PC105.2 PL104.1
AC_DET: PR206.2 PR215.1
AC_DIS: PQ302.2 PR228.1 PR301.1 UE5.A50
AC_PRESENT: RC243.1 UCPU1.AY15 UE5.A54
ACAV_IN: PR314.1 UE5.A64
ACAV_IN_NB: DE11.2 RE102.2 UE5.B20
ALW_PWRGD_3V_5V: PR277.1 PR280.2 PR502.2 PR506.1 PU500.9
ALWON: PR503.1 PR510.1 UE5.A60
AUD_PWR_EN: R1140.1 R1141.1 U664.3 U664.5 U719.5 UCPU1.BA7
AUDIO_VREF: CA87.1 UA2.28
AUX_EN_WOWL: QE14.2 R1186.2 U720.3 UE5.B38
B+: C613.1 C614.1 C615.1 C616.1 C617.1 C1273.1 C1274.1 C1275.1 PC314.1 PC315.1 PC316.1 PC317.1 PC319.1 PC320.1 PC321.1 PJP1002.2 PL301.2 PL500.1 PL600.1 PL700.1 PL800.1 PL900.1 PL1004.2 PL1400.1 PL1402.1 PL1500.1 PL1502.1 PQ200.1 PQ200.2 PQ200.5 PQ200.6 PQ200.7 PQ204.3 PR201.1 PR313.4 PR402.1 PR409.1 PR508.1 PR512.1 PR513.1 Q70.4 R78.1 R531.1 R535.1
B+_1.0V: PC702.1 PC704.1 PC705.1 PC706.1 PL700.2 PU700.8
B+_3V: PC500.1 PC501.1 PC502.1 PC503.1 PL500.2 PU500.2 PU500.3 PU500.4 PU500.5
B+_5V: PC513.1 PC514.1 PC515.1 PC516.1 PC528.1 PC529.1 PR512.2 PR513.2 PU501.2 PU501.3 PU501.4 PU501.5
BAT1_LED#: JKB1.10 RE104.2 UE5.A40
BAT2_LED#: JKB1.9 RE105.2 UE5.B43
BAT_LED#_LV1: LED12.1 R910.2
BAT_LED#_LV2: LED14.1 R911.2
BAT_LED#_LV3: LED10.1 R912.2
BAT_LED#_LV4: LED11.1 R913.2
BAT_LED#_LV5: LED13.1 R916.2
BATBTN#: C2983.1 RPE5.4 SW3.1 SW3.2 UE5.A63
BATDRV#: PQ305.4 PR323.2
BATT_LED#_LV1: Q41.3 UE4.25
BATT_LED#_LV2: QH9.1 UE4.26
BATT_LED#_LV3: QH9.4 UE4.27
BATT_LED#_LV4: QH8.1 UE4.28
BATT_LED#_LV5: QH8.4 UE4.1
BATT_PRS: JBATT1.5 PRP100.8
BATT_VREF: PC407.1 PR410.2 PR413.1 PU400.2 PU400.6
BC_CLK_ECE1117: JKB1.8 UE5.A20
BC_DAT_ECE1117: JKB1.7 RPE5.1 UE5.B21
BC_INT#_ECE1117: JKB1.6 UE5.A19
BEEP: RA24.1 UE5.B19
BIA_PWM_EC: D73.3 UE5.B25
BOARD_ID: CE54.1 RE79.2 UE5.B10
BQ24777_REGN: PC312.1 PR312.1 PR320.2 PR325.1 PU300.24
BST_1.0V: PR703.1 PU700.6
BST_3V: PR500.1 PU500.1
BST_5V: PR505.1 PU501.1
BT_RADIO_DIS#: DZ2.1 RE13.2 UE4.23
BT_RADIO_DIS#_R: DZ2.2 JNGFF1.46
CAM_CBL_DET#: RC280.1 RH438.1 UCPU1.AB11
CAM_CBL_DET#_R: JCAM.2 RH438.2
CFG0: JXDP1.9 RC113.2 RC126.1 UCPU1.E68
CFG1: JXDP1.11 RC112.2 UCPU1.B67
CFG2: JXDP1.15 UCPU1.D65
CFG3: JXDP1.17 RC110.2 RC121.2 UCPU1.D67
CFG4: JXDP1.27 RC109.2 UCPU1.E70
CFG5: JXDP1.29 UCPU1.C68
CFG6: JXDP1.33 UCPU1.D68
CFG7: JXDP1.35 UCPU1.C67
CFG8: JXDP1.10 UCPU1.F71
CFG9: JXDP1.12 UCPU1.G69
CFG10: JXDP1.16 UCPU1.F70
CFG11: JXDP1.18 UCPU1.G68
CFG12: JXDP1.28 UCPU1.H70
CFG13: JXDP1.30 UCPU1.G71
CFG14: JXDP1.34 UCPU1.H69
CFG15: JXDP1.36 UCPU1.G70
CFG16: JXDP1.6 UCPU1.E63
CFG17: JXDP1.4 UCPU1.F63
CFG18: JXDP1.24 UCPU1.E66
CFG19: JXDP1.22 UCPU1.F66
CFG_RCOMP: RC114.1 UCPU1.E60
CHAGER_SRC: PC301.1 PC302.1 PC303.1 PC304.1 PC305.1 PC306.1 PC307.1 PL300.2 PQ303.5
CHARGER_SMBCLK: PR311.1 RE56.1 UE5.B50
CHARGER_SMBDAT: PR309.1 RE55.1 UE5.A47
CHG_BTS: PR308.1 PU300.25
CHG_BTS_C: PC322.1 PR308.2
CHG_LGATE: PQ304.4 PU300.23
CHG_SW: PC322.2 PL301.1 PQ303.1 PQ303.2 PQ303.3 PQ304.5 PR321.1 PU300.27
CHG_UGATE: PQ303.4 PU300.26
CL_CK: R1212.2 UCPU1.G3
CL_CK_R: JNGFF1.34 R1212.1
CL_DAT: R1210.2 UCPU1.G2
CL_DAT_R: JNGFF1.32 R1210.1
CL_RST#: R1200.2 UCPU1.G1
CL_RST#_R: JNGFF1.30 R1200.1
CLK0_PCIE_TBT: UCPU1.C42 UT1.V19
CLK0_PCIE_TBT#: UCPU1.D42 UT1.T19
CLK1_PCIE_WLAN: C1302.1 JNGFF1.39 UCPU1.A42
CLK1_PCIE_WLAN#: C1301.1 JNGFF1.41 UCPU1.B42
CLK_ITPXDP_N: JXDP1.42 RC297.2
CLK_ITPXDP_N_R: RC297.1 UCPU1.F43
CLK_ITPXDP_P: JXDP1.40 RC298.2
CLK_ITPXDP_P_R: RC298.1 UCPU1.E43
CLK_LPC_DEBUG: CC5.2 JLPDE1.10 RC22.2
CLK_PCI_MEC: CC4.2 RC18.2 RE80.1 UE5.A29
CLK_PCIE_MMI: JIO1.20 UCPU1.E38
CLK_PCIE_MMI#: JIO1.22 UCPU1.E40
CLK_PCIE_SSD: JNGFF2.55 UCPU1.C40
CLK_PCIE_SSD#: JNGFF2.53 UCPU1.D40
CLK_SMB: JBATT1.3 PRP100.6
CLK_TP_SIO: C1229.1 JTP1.8 MD9.3 RE6.2 UE5.A37
CLKREQ_PCIE#0: RC63.2 RT21.2 UCPU1.AR10 UT1.AC5
CLKREQ_PCIE#1: JNGFF1.45 RC47.2 UCPU1.AT7
CLKREQ_PCIE#3: JNGFF2.52 RC59.2 UCPU1.AT10
CLKREQ_PCIE#5: JIO1.30 RC190.2 UCPU1.AU7
CLKRUN#: RC27.2 UCPU1.AW11 UE5.A32
COMP_IA: PC1056.2 PR1123.2 PU1000.16
COMP_VSA: PC1081.1 PR1090.1 PU1000.24
CORE_SNUB: PC1115.1 PR1101.2
CORE_SW: PL1100.1 PR1101.1 PR1130.1 PU1100.4
CORE_VID0: PR1419.1 UCPU1.AN11
CORE_VID1: PR1420.1 UCPU1.AN13
CPU_B+: PC1073.1 PC1100.1 PC1101.1 PC1102.1 PC1103.1 PC1104.1 PC1105.1 PC1107.1 PC1108.1 PC1109.1 PC1110.1 PC1111.1 PC1112.1 PC1113.1 PC1117.1 PC1118.1 PC1120.1 PC1121.1 PC1122.1 PC1123.1 PC1124.1 PC1127.1 PC1128.1 PC1135.1 PJP1002.1 PR1066.2 PU1100.5 PU1101.5 PU1102.5
CPU_DDI1_AUXN: CT26.2 UCPU1.G50
CPU_DDI1_AUXN_C: CT26.1 UT1.W11
CPU_DDI1_AUXP: CT25.2 UCPU1.F50
CPU_DDI1_AUXP_C: CT25.1 UT1.Y11
CPU_DDI2_AUXN: CT107.2 UCPU1.E48
CPU_DDI2_AUXN_C: CT107.1 UT1.W12
CPU_DDI2_AUXP: CT108.2 UCPU1.F48
CPU_DDI2_AUXP_C: CT108.1 UT1.Y12
CPU_DP1_CTRL_CLK: RC175.1 UCPU1.L13 UT1.Y5
CPU_DP1_CTRL_DATA: RC178.1 UCPU1.L12 UT1.R4
CPU_DP1_HPD: RC312.2 UCPU1.L9 UT1.AA2
CPU_DP2_CTRL_CLK: RC176.1 UCPU1.N7 UT1.Y8
CPU_DP2_CTRL_DATA: RC177.1 UCPU1.N8 UT1.N4
CPU_DP2_HPD: RC242.2 UCPU1.L7 UT1.Y6
CPU_POPIRCOMP: RC88.1 UCPU1.AT16
CPU_XDP_PRDY#: JXDP1.5 UCPU1.D61
CPU_XDP_PREQ#: JXDP1.3 RC138.2 UCPU1.D56
CPVEE: C1205.1 UA2.34
CSI2_COMP: RC3.1 UCPU1.E13
CSSN_1: PR300.2 PR304.1
CSSP_1: PR300.3 PR303.1
CV2_ON: R251.2 UE5.A9
DAT_SMB: JBATT1.4 PRP100.7
DAT_TP_SIO: C1226.1 JTP1.7 MD9.2 RE7.2 UE5.B40
DBC_I2C_EN: U48.5 UE4.2
DCIN_ACOK: DE11.1 PC215.1 PQ219.5 PQ220.2 PR217.1 PR249.1 PR250.1 PR255.2 PR262.2 PU203.7
DCIN_ACOK#: PQ219.2 PQ219.3 PR220.1 PR251.1 PR256.2 PR284.1
DDI1_PTX_TBRX_N0: CT18.2 UCPU1.E55
DDI1_PTX_TBRX_N0_C: CT18.1 UT1.AC7
DDI1_PTX_TBRX_N1: CT20.2 UCPU1.E58
DDI1_PTX_TBRX_N1_C: CT20.1 UT1.AC9
DDI1_PTX_TBRX_N2: CT22.2 UCPU1.F53
DDI1_PTX_TBRX_N2_C: CT22.1 UT1.AC11
DDI1_PTX_TBRX_N3: CT24.2 UCPU1.F56
DDI1_PTX_TBRX_N3_C: CT24.1 UT1.AC13
DDI1_PTX_TBRX_P0: CT17.2 UCPU1.F55
DDI1_PTX_TBRX_P0_C: CT17.1 UT1.AB7
DDI1_PTX_TBRX_P1: CT19.2 UCPU1.F58
DDI1_PTX_TBRX_P1_C: CT19.1 UT1.AB9
DDI1_PTX_TBRX_P2: CT21.2 UCPU1.G53
DDI1_PTX_TBRX_P2_C: CT21.1 UT1.AB11
DDI1_PTX_TBRX_P3: CT23.2 UCPU1.G56
DDI1_PTX_TBRX_P3_C: CT23.1 UT1.AB13
DDI2_PTX_TBRX_N0: CT30.2 UCPU1.C50
DDI2_PTX_TBRX_N0_C: CT30.1 UT1.AC15
DDI2_PTX_TBRX_N1: CT32.2 UCPU1.C52
DDI2_PTX_TBRX_N1_C: CT32.1 UT1.AC17
DDI2_PTX_TBRX_N2: CT34.2 UCPU1.A50
DDI2_PTX_TBRX_N2_C: CT34.1 UT1.AC19
DDI2_PTX_TBRX_N3: CT36.2 UCPU1.D51
DDI2_PTX_TBRX_N3_C: CT36.1 UT1.AC21
DDI2_PTX_TBRX_P0: CT29.2 UCPU1.D50
DDI2_PTX_TBRX_P0_C: CT29.1 UT1.AB15
DDI2_PTX_TBRX_P1: CT31.2 UCPU1.D52
DDI2_PTX_TBRX_P1_C: CT31.1 UT1.AB17
DDI2_PTX_TBRX_P2: CT33.2 UCPU1.B50
DDI2_PTX_TBRX_P2_C: CT33.1 UT1.AB19
DDI2_PTX_TBRX_P3: CT35.2 UCPU1.C51
DDI2_PTX_TBRX_P3_C: CT35.1 UT1.AB21
DDR_A0_ZQ0: RD51.1 UD19.B3
DDR_A0_ZQ1: RD53.1 UD19.B4
DDR_A1_ZQ0: RD52.1 UD20.B3
DDR_A1_ZQ1: RD54.1 UD20.B4
DDR_A_CA1_0: RD59.1 UCPU1.BA51 UD19.R2
DDR_A_CA1_1: RD61.1 UCPU1.BB54 UD19.P2
DDR_A_CA1_2: RD63.1 UCPU1.BA52 UD19.N2
DDR_A_CA1_3: RD65.1 UCPU1.AY52 UD19.N3
DDR_A_CA1_4: RD67.1 UCPU1.AW52 UD19.M3
DDR_A_CA1_5: RD69.1 UCPU1.AY55 UD19.F3
DDR_A_CA1_6: RD71.1 UCPU1.AW54 UD19.E3
DDR_A_CA1_7: RD73.1 UCPU1.BA54 UD19.E2
DDR_A_CA1_8: RD75.1 UCPU1.BA55 UD19.D2
DDR_A_CA1_9: RD77.1 UCPU1.AY54 UD19.C2
DDR_A_CA2_0: RD79.1 UCPU1.AU46 UD20.R2
DDR_A_CA2_1: RD81.1 UCPU1.AU48 UD20.P2
DDR_A_CA2_2: RD83.1 UCPU1.AT46 UD20.N2
DDR_A_CA2_3: RD85.1 UCPU1.AU50 UD20.N3
DDR_A_CA2_4: RD87.1 UCPU1.AU52 UD20.M3
DDR_A_CA2_5: RD89.1 UCPU1.AY51 UD20.F3
DDR_A_CA2_6: RD91.1 UCPU1.AT48 UD20.E3
DDR_A_CA2_7: RD93.1 UCPU1.AT50 UD20.E2
DDR_A_CA2_8: RD95.1 UCPU1.BB50 UD20.D2
DDR_A_CA2_9: RD97.1 UCPU1.AY50 UD20.C2
DDR_A_CKE0: RD103.1 UCPU1.BA56 UD19.K3
DDR_A_CKE1: RD105.1 UCPU1.BB56 UD19.K4
DDR_A_CKE2: RD107.1 UCPU1.AW56 UD20.K3
DDR_A_CKE3: RD109.1 UCPU1.AY56 UD20.K4
DDR_A_CLK0: RD35.1 UCPU1.AT53 UD19.J3
DDR_A_CLK1: RD46.1 UCPU1.AT55 UD20.J3
DDR_A_CLK#0: RD37.1 UCPU1.AU53 UD19.J2
DDR_A_CLK#1: RD45.1 UCPU1.AU55 UD20.J2
DDR_A_CS#0: RD99.1 UCPU1.AU45 UD19.L3 UD20.L3
DDR_A_CS#1: RD101.1 UCPU1.AU43 UD19.L4 UD20.L4
DDR_A_D0: UCPU1.AL71 UD19.C8
DDR_A_D1: UCPU1.AL68 UD19.B11
DDR_A_D2: UCPU1.AN68 UD19.C9
DDR_A_D3: UCPU1.AN69 UD19.B10
DDR_A_D4: UCPU1.AL70 UD19.B9
DDR_A_D5: UCPU1.AL69 UD19.B8
DDR_A_D6: UCPU1.AN70 UD19.C11
DDR_A_D7: UCPU1.AN71 UD19.C10
DDR_A_D8: UCPU1.AR70 UD19.R10
DDR_A_D9: UCPU1.AR68 UD19.R11
DDR_A_D10: UCPU1.AU71 UD19.R9
DDR_A_D11: UCPU1.AU68 UD19.T10
DDR_A_D12: UCPU1.AR71 UD19.T11
DDR_A_D13: UCPU1.AR69 UD19.R8
DDR_A_D14: UCPU1.AU70 UD19.T9
DDR_A_D15: UCPU1.AU69 UD19.T8
DDR_A_D16: UCPU1.AF65 UD19.N9
DDR_A_D17: UCPU1.AF64 UD19.M8
DDR_A_D18: UCPU1.AK65 UD19.N11
DDR_A_D19: UCPU1.AK64 UD19.N10
DDR_A_D20: UCPU1.AF66 UD19.M9
DDR_A_D21: UCPU1.AF67 UD19.P9
DDR_A_D22: UCPU1.AK67 UD19.M11
DDR_A_D23: UCPU1.AK66 UD19.M10
DDR_A_D24: UCPU1.AF70 UD19.F11
DDR_A_D25: UCPU1.AF68 UD19.F10
DDR_A_D26: UCPU1.AH71 UD19.D9
DDR_A_D27: UCPU1.AH68 UD19.F8
DDR_A_D28: UCPU1.AF71 UD19.E10
DDR_A_D29: UCPU1.AF69 UD19.E11
DDR_A_D30: UCPU1.AH70 UD19.E9
DDR_A_D31: UCPU1.AH69 UD19.F9
DDR_A_D32: UCPU1.BB65 UD20.B9
DDR_A_D33: UCPU1.AW65 UD20.C11
DDR_A_D34: UCPU1.AW63 UD20.B11
DDR_A_D35: UCPU1.AY63 UD20.C8
DDR_A_D36: UCPU1.BA65 UD20.B8
DDR_A_D37: UCPU1.AY65 UD20.B10
DDR_A_D38: UCPU1.BA63 UD20.C10
DDR_A_D39: UCPU1.BB63 UD20.C9
DDR_A_D40: UCPU1.BA61 UD20.T9
DDR_A_D41: UCPU1.AW61 UD20.R9
DDR_A_D42: UCPU1.BB59 UD20.T11
DDR_A_D43: UCPU1.AW59 UD20.T10
DDR_A_D44: UCPU1.BB61 UD20.R8
DDR_A_D45: UCPU1.AY61 UD20.T8
DDR_A_D46: UCPU1.BA59 UD20.R10
DDR_A_D47: UCPU1.AY59 UD20.R11
DDR_A_D48: UCPU1.AT66 UD20.E10
DDR_A_D49: UCPU1.AU66 UD20.F10
DDR_A_D50: UCPU1.AP65 UD20.F8
DDR_A_D51: UCPU1.AN65 UD20.D9
DDR_A_D52: UCPU1.AN66 UD20.E9
DDR_A_D53: UCPU1.AP66 UD20.E11
DDR_A_D54: UCPU1.AT65 UD20.F9
DDR_A_D55: UCPU1.AU65 UD20.F11
DDR_A_D56: UCPU1.AT61 UD20.N9
DDR_A_D57: UCPU1.AU61 UD20.M9
DDR_A_D58: UCPU1.AP60 UD20.N11
DDR_A_D59: UCPU1.AN60 UD20.N10
DDR_A_D60: UCPU1.AN61 UD20.M8
DDR_A_D61: UCPU1.AP61 UD20.P9
DDR_A_D62: UCPU1.AT60 UD20.M10
DDR_A_D63: UCPU1.AU60 UD20.M11
DDR_A_DQS0: UCPU1.AM69 UD19.D10
DDR_A_DQS1: UCPU1.AT70 UD19.P10
DDR_A_DQS2: UCPU1.AH65 UD19.L10
DDR_A_DQS3: UCPU1.AG70 UD19.G10
DDR_A_DQS4: UCPU1.AY64 UD20.D10
DDR_A_DQS5: UCPU1.BA60 UD20.P10
DDR_A_DQS6: UCPU1.AR65 UD20.G10
DDR_A_DQS7: UCPU1.AR60 UD20.L10
DDR_A_DQS#0: UCPU1.AM70 UD19.D11
DDR_A_DQS#1: UCPU1.AT69 UD19.P11
DDR_A_DQS#2: UCPU1.AH66 UD19.L11
DDR_A_DQS#3: UCPU1.AG69 UD19.G11
DDR_A_DQS#4: UCPU1.BA64 UD20.D11
DDR_A_DQS#5: UCPU1.AY60 UD20.P11
DDR_A_DQS#6: UCPU1.AR66 UD20.G11
DDR_A_DQS#7: UCPU1.AR61 UD20.L11
DDR_A_ODT0: RD117.1 UCPU1.AT45 UD19.J8 UD20.J8
DDR_B0_ZQ0: RD57.1 UD21.B3
DDR_B0_ZQ1: RD58.1 UD21.B4
DDR_B1_ZQ0: RD55.1 UD22.B3
DDR_B1_ZQ1: RD56.1 UD22.B4
DDR_B_CA1_0: RD60.1 UCPU1.AY48 UD21.R2
DDR_B_CA1_1: RD62.1 UCPU1.AP50 UD21.P2
DDR_B_CA1_2: RD64.1 UCPU1.BA48 UD21.N2
DDR_B_CA1_3: RD66.1 UCPU1.BB48 UD21.N3
DDR_B_CA1_4: RD68.1 UCPU1.AP48 UD21.M3
DDR_B_CA1_5: RD70.1 UCPU1.AP52 UD21.F3
DDR_B_CA1_6: RD72.1 UCPU1.AN50 UD21.E3
DDR_B_CA1_7: RD74.1 UCPU1.AN48 UD21.E2
DDR_B_CA1_8: RD76.1 UCPU1.AN53 UD21.D2
DDR_B_CA1_9: RD78.1 UCPU1.AN52 UD21.C2
DDR_B_CA2_0: RD80.1 UCPU1.BA43 UD22.R2
DDR_B_CA2_1: RD82.1 UCPU1.AY43 UD22.P2
DDR_B_CA2_2: RD84.1 UCPU1.AY44 UD22.N2
DDR_B_CA2_3: RD86.1 UCPU1.AW44 UD22.N3
DDR_B_CA2_4: RD88.1 UCPU1.BB44 UD22.M3
DDR_B_CA2_5: RD90.1 UCPU1.AY47 UD22.F3
DDR_B_CA2_6: RD92.1 UCPU1.BA44 UD22.E3
DDR_B_CA2_7: RD94.1 UCPU1.AW46 UD22.E2
DDR_B_CA2_8: RD96.1 UCPU1.AY46 UD22.D2
DDR_B_CA2_9: RD98.1 UCPU1.BA46 UD22.C2
DDR_B_CKE0: RD104.1 UCPU1.AN56 UD21.K3
DDR_B_CKE1: RD106.1 UCPU1.AP55 UD21.K4
DDR_B_CKE2: RD108.1 UCPU1.AN55 UD22.K3
DDR_B_CKE3: RD110.1 UCPU1.AP53 UD22.K4
DDR_B_CLK0: RD36.1 UCPU1.AP45 UD21.J3
DDR_B_CLK1: RD47.1 UCPU1.AP46 UD22.J3
DDR_B_CLK#0: RD38.1 UCPU1.AN45 UD21.J2
DDR_B_CLK#1: RD48.1 UCPU1.AN46 UD22.J2
DDR_B_CS#0: RD100.1 UCPU1.BB42 UD21.L3 UD22.L3
DDR_B_CS#1: RD102.1 UCPU1.AY42 UD21.L4 UD22.L4
DDR_B_D0: UCPU1.AY39 UD21.E11
DDR_B_D1: UCPU1.AW39 UD21.F10
DDR_B_D2: UCPU1.AY37 UD21.F11
DDR_B_D3: UCPU1.AW37 UD21.D9
DDR_B_D4: UCPU1.BB39 UD21.F9
DDR_B_D5: UCPU1.BA39 UD21.E10
DDR_B_D6: UCPU1.BA37 UD21.F8
DDR_B_D7: UCPU1.BB37 UD21.E9
DDR_B_D8: UCPU1.AY35 UD21.T11
DDR_B_D9: UCPU1.AW35 UD21.T10
DDR_B_D10: UCPU1.AY33 UD21.T9
DDR_B_D11: UCPU1.AW33 UD21.R9
DDR_B_D12: UCPU1.BB35 UD21.R11
DDR_B_D13: UCPU1.BA35 UD21.R10
DDR_B_D14: UCPU1.BA33 UD21.T8
DDR_B_D15: UCPU1.BB33 UD21.R8
DDR_B_D16: UCPU1.AU40 UD21.B10
DDR_B_D17: UCPU1.AT40 UD21.B9
DDR_B_D18: UCPU1.AT37 UD21.C11
DDR_B_D19: UCPU1.AU37 UD21.B11
DDR_B_D20: UCPU1.AR40 UD21.B8
DDR_B_D21: UCPU1.AP40 UD21.C8
DDR_B_D22: UCPU1.AP37 UD21.C9
DDR_B_D23: UCPU1.AR37 UD21.C10
DDR_B_D24: UCPU1.AT33 UD21.N11
DDR_B_D25: UCPU1.AU33 UD21.M10
DDR_B_D26: UCPU1.AU30 UD21.N9
DDR_B_D27: UCPU1.AT30 UD21.P9
DDR_B_D28: UCPU1.AR33 UD21.M11
DDR_B_D29: UCPU1.AP33 UD21.N10
DDR_B_D30: UCPU1.AR30 UD21.M8
DDR_B_D31: UCPU1.AP30 UD21.M9
DDR_B_D32: UCPU1.AY31 UD22.E11
DDR_B_D33: UCPU1.AW31 UD22.F8
DDR_B_D34: UCPU1.AY29 UD22.F9
DDR_B_D35: UCPU1.AW29 UD22.E9
DDR_B_D36: UCPU1.BB31 UD22.D9
DDR_B_D37: UCPU1.BA31 UD22.E10
DDR_B_D38: UCPU1.BA29 UD22.F10
DDR_B_D39: UCPU1.BB29 UD22.F11
DDR_B_D40: UCPU1.AY27 UD22.B8
DDR_B_D41: UCPU1.AW27 UD22.C8
DDR_B_D42: UCPU1.AY25 UD22.B9
DDR_B_D43: UCPU1.AW25 UD22.B10
DDR_B_D44: UCPU1.BB27 UD22.C10
DDR_B_D45: UCPU1.BA27 UD22.C9
DDR_B_D46: UCPU1.BA25 UD22.C11
DDR_B_D47: UCPU1.BB25 UD22.B11
DDR_B_D48: UCPU1.AU27 UD22.T10
DDR_B_D49: UCPU1.AT27 UD22.T11
DDR_B_D50: UCPU1.AT25 UD22.T9
DDR_B_D51: UCPU1.AU25 UD22.R9
DDR_B_D52: UCPU1.AP27 UD22.R11
DDR_B_D53: UCPU1.AN27 UD22.R10
DDR_B_D54: UCPU1.AN25 UD22.R8
DDR_B_D55: UCPU1.AP25 UD22.T8
DDR_B_D56: UCPU1.AT22 UD22.M9
DDR_B_D57: UCPU1.AU22 UD22.N9
DDR_B_D58: UCPU1.AU21 UD22.M11
DDR_B_D59: UCPU1.AT21 UD22.N11
DDR_B_D60: UCPU1.AN22 UD22.M8
DDR_B_D61: UCPU1.AP22 UD22.P9
