# Allegro board LAD841PR10-0621.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SD_RCOMP: length 2
  TOP w0.127: RC96.1 147.84,62.44 148.43,61.86 v2(148.43,61.82)
  BOTTOM w0.127: UCPU1.AB7 148.74,61.51 v2(148.43,61.82)
SIO_EXT_SCI#: length 59.3
  TOP w0.127: UE5.A33 176.94,67.02 176.42,67.53 176.42,68.63 v2(176.35,68.71) 175.87,68.23 v3(175.87,67.92) ; RC237.2 148.69,50.83 147.66,51.87 147.66,54.68 147.98,55.01 v2(148.08,55.01)
  IN1 w0.081: v2(148.08,55.01) 147.6,54.52 147.6,51.74 150.53,48.81 152.45,48.81 152.71,48.55 154,48.55 154,48.54 154.71,48.54 155.45,47.8 155.45,47.41 156.15,46.72 158.5,46.72 158.77,46.99 162.36,46.99 167.66,52.29 167.66,54.05 167.03,54.68 167.03,55.81 167.33,56.11 167.33,56.7 168.29,57.66 168.29,59.45 170.34,61.5 170.34,64.24 172.22,66.12 172.22,66.8 172.1,66.92 172.1,67.61 172.4,67.9 173.82,67.9 174.68,68.76 176.29,68.76 v2(176.35,68.71)
  BOTTOM w0.076: UCPU1.AN7 148.48,55.4 v2(148.08,55.01)
SIO_EXT_SMI#: length 72.8
  TOP w0.127: UE5.A6 188.06,62.02 188.48,62.02 v2(188.72,61.78)
  BOTTOM w0.127: UCPU1.A6 149.16,72.1 149.16,72.55 150.05,73.45 151.29,73.45 152.38,74.53 RC236.2 152.98,76.31 152.98,77.2 155.12,79.34 176.74,79.34 178.28,77.8 178.28,76.37 178.74,75.92 181.15,75.92 181.35,75.72 183.95,75.72 184.19,75.96 184.75,75.96 186.51,77.72 186.51,78.05 186.97,78.52 189.72,78.52 190.27,77.96 190.27,76.82 191.11,75.99 191.11,74.35 192.57,72.9 192.85,72.9 194.22,71.53 194.22,68.34 194.88,67.68 194.88,66.7 194.7,66.53 194.7,66.23 192.62,64.14 192.62,63.33 192.25,62.97 191.82,62.97 v3(190.57,61.72) 190.36,61.51 189.2,61.51 188.93,61.78 v2(188.72,61.78)
SIO_EXT_WAKE#: length 59.5
  TOP w0.127: v2(185.8,61.22) 186.06,60.96 186.59,60.96 186.9,61.27 UE5.B5 ; v2(157.28,57.87) 157.46,57.87 v3(157.77,57.56)
  IN3 w0.089: v2(157.28,57.87) 157.46,57.87 159.91,60.32 159.91,60.58 160.26,60.93 161.58,60.93 162.28,61.63 162.28,62.72 163.6,64.03 167.67,64.03 169.03,65.4 170.76,65.4 171.42,66.06 171.88,66.06 176.68,70.86 178.8,70.86 179.2,71.26 183.74,71.26 184.22,70.77 187.65,70.77 189.41,69.01 189.41,66.73 189.03,66.36 188.55,66.36 188.33,66.14 188.33,63.57 186.61,61.86 186.16,61.86 185.8,61.5 v2(185.8,61.22)
  BOTTOM w0.076: 152.14,58.48 151.6,58.48 151.42,58.66 151.42,58.97 151.26,59.14 151.05,59.14 150.82,59.37 UCPU1.AD3
  BOTTOM w0.127: v2(157.28,57.87) 157.05,57.64 156.14,57.64 RC283.2 155.19,57.67 154.78,57.67 153.99,58.45 152.32,58.45 152.3,58.48 152.14,58.48
SIO_PWRBTN#: length 173
  TOP w0.127: v2(180.99,60.41) 181.3,60.41 181.65,60.06 181.65,59.03 181.61,58.99 UE5.B58 ; JXDP1.41 68.6,74.93 v2(68.99,75.32) 68.81,75.5 CC269.1 69.67,75.9 RC241.2
  IN1 w0.081: v2(98.53,64.04) 100.04,65.56 107.56,65.56 108.21,66.21 109.66,66.21 109.96,66.51 111.45,66.51 112.29,67.35 113.3,67.35 113.6,67.04 117.12,67.04 117.96,66.19 118.98,66.19 120.19,64.98 125.82,64.98 127.86,67.02 133.28,67.02 134.98,65.33 134.98,58.81 v2(135.79,58)
  IN2 w0.089: v2(166.42,62.14) 167.45,61.1 172.67,61.1 176.27,57.51 176.9,57.51 177.17,57.78 177.17,58.16 178.76,59.75 179.73,59.75 179.93,59.96 180.43,59.96 180.88,60.41 v2(180.99,60.41)
  IN3 w0.089: v2(68.99,75.32) 68.99,74.93 69.86,74.05 78.58,74.05 80.16,72.47 82.46,72.47 83.06,73.08 90.11,73.08 90.49,72.7 91.31,72.7 92.81,74.2 94.38,74.2 96.15,72.42 v2(98.4,72.42) ; v2(166.42,62.14) 166.41,62.12 164.8,62.12 164.56,61.89 163.45,61.89 160.93,59.36 160.93,58.31 158.73,56.11 157.63,56.11 154.63,53.11 152.4,53.11 150.18,50.88 146.43,50.88 146.11,50.56 145.46,50.56 144.29,49.39 144.29,49.1 143.81,48.62 v2(143.52,48.62) 142.97,49.18 142.97,51.55 142.16,52.36 142.16,56.45 141.81,56.8 138.18,56.8 136.95,58.03 136.95,58.18 136.72,58.41 136.21,58.41 136.15,58.36 136.15,58.36 v2(135.79,58)
  BOTTOM w0.076: UCPU1.BA15 143.3,50.07 143.3,48.84 v2(143.52,48.62)
  BOTTOM w0.127: v2(98.53,64.04) 98.83,63.74 100.51,63.74 100.84,64.07 100.84,64.31 102.27,65.74 105.05,65.74 105.76,66.45 105.76,68.12 v3(106.21,68.58) 106.5,68.87 106.5,69.49 105.89,70.1 101.93,70.1 99.6,72.42 v2(98.4,72.42)
SIO_RCIN#: length 67.1
  TOP w0.127: v2(181.31,69.43) 181.31,69.43 181.36,69.37 181.36,68.72 UE5.A27
  IN1 w0.081: v2(181.31,69.43) 181.31,68.77 180.58,68.04 178.96,68.04 177.29,66.38 175.97,66.38 175.44,65.85 175.44,65.19 173.57,63.32 173.57,61.29 173.48,61.21 173.48,59.62 171.84,57.98 171.84,52.87 171.5,52.53 171.5,48.59 169.66,46.74 167.67,46.74 163.37,42.44 161.03,42.44 160.18,43.29 157.29,43.29 155.94,41.94 154.96,41.94 153.87,40.85 152.96,40.85 v2(152.12,41.69)
  BOTTOM w0.076: 145.12,47.32 144.55,47.9 144.55,48.56 144.37,48.74 144.37,49.83 144.41,49.94 144.41,50.06 144.35,50.27 144.35,50.42 144.4,50.58 144.4,50.66 144.58,51.22 UCPU1.AW13
  BOTTOM w0.127: v2(152.12,41.69) 150.98,41.69 149.81,42.86 v3(148.11,42.86) 147.35,42.86 146.84,43.37 146.84,43.83 146.53,44.14 146.53,44.94 RC16.2 147.04,45.65 146.15,46.54 145.7,46.54 145.42,46.82 145.42,47.03 145.12,47.32
SIO_SLP_A#: length 114.9
  TOP w0.127: UE5.B28 181.61,67.54 181.89,67.27 v2(181.89,67.17)
  IN1 w0.081: v2(142.6,55.01) 142.69,55.01 143,54.7 143,52.92 144.07,51.85 144.45,51.85 144.83,51.47 145.41,51.47 146.42,50.47 147.59,50.47 150.07,47.98 151.98,47.98 152.5,47.46 152.5,46.85 153.42,45.93 158.61,45.93 159.04,46.36 163.94,46.36 167.01,49.43 167.01,50.34 170.3,53.63 170.3,56.05 169.34,57.01 169.34,59.01 171.86,61.53 171.86,62.26 172.22,62.62 172.22,63.87 173.58,65.23 173.58,67.04 174.84,68.3 175.86,68.3 176.07,68.09 176.6,68.09 177.9,69.38 177.9,69.48 178.34,69.92 178.74,69.92 178.91,70.1 179.35,70.1 179.44,70.01 179.87,70.01 180.53,70.67 181.39,70.67 181.61,70.44 181.61,69.76 181.74,69.63 181.74,67.34 181.89,67.19 v2(181.89,67.17)
  IN4 w0.089: v2(197.21,31.68) 196.77,32.12 196.77,34.02 194.98,35.81 194.98,48.49 193.36,50.12 193.12,50.12 190.7,52.54 190.57,52.54 189.8,53.31 189.8,57.23 188.89,58.13 188.21,58.13 187.44,58.9 187.44,60.55 187.29,60.7 187.29,62.31 186.87,62.72 186.17,62.72 186.14,62.69 184.74,62.69 181.89,65.54 v2(181.89,67.17)
  BOTTOM w0.076: UCPU1.AN16 v2(142.6,55.01)
  BOTTOM w0.127: v2(197.21,31.68) 198.91,33.39 200.76,33.39 JAPS1.6
SIO_SLP_S0#: length 174
  TOP w0.127: RE92.1 185.4,50.2 185.78,49.82 v2(185.88,49.82) ; v2(169.67,55.36) 170.37,55.36 171.56,54.17 172.73,54.17 PR1400.1 ; v2(165.81,69.71) 165.81,69.92 165.4,70.33 UC9.1 ; PR1411.1 195.51,78.72 v2(195.36,78.57)
  IN1 w0.081: v2(145.39,53.13) 145.66,53.13 146.08,52.71 146.34,52.71 150.44,48.6 152.36,48.6 152.63,48.34 154.62,48.34 155.25,47.71 155.25,47.33 156.21,46.36 158.44,46.36 158.86,46.78 163.77,46.78 165.99,49 165.99,50.33 169.67,54.01 v2(169.67,55.36) ; v2(165.81,69.71) 167.41,71.31 167.41,73.46 170.7,76.75 176.04,76.75 176.31,76.48 187.4,76.48 189.04,78.12 193.1,78.12 193.55,78.57 v2(195.36,78.57)
  IN2 w0.089: v2(195.36,78.57) 197.03,78.57 198.27,77.33 201.96,77.33 202.9,76.39 202.9,73.54 203.63,72.8 203.63,70.6 204.56,69.67 204.56,64.25 203.95,63.64 203.95,60.44 204.88,59.51 204.88,54.96 200.65,50.74 200.65,46.99 201.51,46.14 v2(201.51,45.5) 202.29,44.71 202.29,38.92 201.02,37.65 201.02,29.83 v2(199.95,28.76)
  BOTTOM w0.127: v2(145.39,53.13) 145.71,53.45 UCPU1.AT11 ; JAPS1.15 200.08,28.89 v2(199.95,28.76) ; v2(185.88,49.82) 185.9,49.85 187.58,49.85 188.66,48.76 190.39,48.76 190.48,48.68 191.56,48.68 194,51.12 v3(196.04,51.12) 197.7,51.12 198.93,49.9 198.93,48.42 201.51,45.84 v2(201.51,45.5) ; v2(165.81,69.71) 165.9,69.71 167.84,67.77 167.84,65.67 168.22,65.3 168.22,63.24 169.42,62.03 169.42,55.61 v2(169.67,55.36)
SIO_SLP_S3#: length 393.6
  TOP w0.127: RT119.1 38.46,52.41 v2(38.37,52.32) ; UC11.1 51.78,42.24 v2(51.16,42.85) ; UE5.A35 177.16,66.02 176.34,66.02 v2(176.27,65.95)
  IN1 w0.081: v2(189.77,62.07) 189.77,61.77 v2(192.04,59.5) 191.11,58.57 189.33,58.57 188.06,57.3 188.06,56.72 190.19,54.59 190.19,53.52 190.87,52.84 190.87,51.46 189.13,49.72 189.13,48.32 188.23,47.41 185.82,47.41 184.93,46.53 184.93,45.27 183.15,43.49 178.59,43.49 178.41,43.68 v2(177.16,43.68)
  IN2 w0.089: v2(177.16,43.68) 176.85,43.36 176.85,42.97 176.45,42.58 176.45,40.8 176.1,40.44 176.1,37.65 175.44,36.99 175.44,22.34 174.49,21.38 174.49,15.21 172.79,13.52 132.44,13.52 130.11,15.85 128.03,15.85 125.95,13.76 117.06,13.76 115.58,15.24 111.82,15.24 111.22,15.85 108.95,15.85 108.04,14.94 101.03,14.94 99.63,16.33 95.59,16.33 94.64,15.38 65.67,15.38 65.15,15.89 54.95,15.89 54.35,16.49 51.45,16.49 50.56,15.6 42.18,15.6 42.14,15.64 40.12,15.64 39,16.76 37.91,16.76 33.43,21.24 33.43,21.8 34.59,22.97 34.59,25.36 34,25.94 34,30.27 35.5,31.76 35.5,32.11 34.98,32.62 34.98,38.94 34.51,39.41 34.51,40.8 35.08,41.37 35.08,43.88 35.7,44.5 35.7,48.91 38.37,51.58 v2(38.37,52.32)
  IN3 w0.089: v2(194.21,67.37) 194.21,66.99 193.84,66.62 193.84,65.43 193.63,65.22 193.63,63.07 192.17,61.61 190.23,61.61 v2(189.77,62.07) ; v2(177.16,43.68) 176.99,43.84 175.71,43.84 174.62,42.76 173.53,42.76 173.08,43.22 172.49,43.22 171.89,42.61 170.53,42.61 170.04,42.12 164.57,42.12 163.2,40.75 162.53,40.75 160.42,38.64 158.11,38.64 v2(157.81,38.34)
  IN4 w0.081: v2(157.81,38.34) 157.81,38.87 156.43,40.25 155.86,40.25 155.08,41.03 155.08,41.41 153.46,43.03 153.46,44.81 152.45,45.83 150.43,45.83 150,45.39 148.86,45.39 148.46,45.79 148.46,48.74 145.55,51.66 145.06,51.66 144.64,52.08 144.22,52.08 143.92,52.38 143.92,53.97 v2(143.51,54.37)
  IN4 w0.089: v2(198.55,34.4) 197.92,34.4 196.09,36.23 196.09,49.66 193.82,51.93 193.82,54.72 191.5,57.04 191.5,57.82 190.47,58.85 190.47,61.38 v2(189.77,62.07)
  BOTTOM w0.076: UCPU1.AP15 v2(143.51,54.37)
  BOTTOM w0.127: v2(176.27,65.95) 176.33,66.01 177.44,66.01 177.65,65.79 177.65,63.72 177.8,63.57 178.82,63.57 179.13,63.27 179.13,62.78 179.29,62.62 184.8,62.62 184.88,62.69 186.2,62.69 186.24,62.73 188.74,62.73 R249.2 189.4,62.07 v2(189.77,62.07) ; v2(192.04,59.5) 192.06,59.5 191.56,59 UC10.1 ; U729.1 189.59,77.84 189.77,77.66 189.77,76.58 190.55,75.8 190.55,74.2 192.36,72.39 192.64,72.39 193.71,71.31 193.71,67.91 194.21,67.41 v2(194.21,67.37) ; JAPS1.2 199.54,35.39 v2(198.55,34.4) ; v2(38.37,52.32) 38.37,51.31 39.95,49.73 41.03,49.73 41.31,49.45 42.49,49.45 43.05,48.9 44.25,48.9 44.69,49.34 49.49,49.34 50.57,48.26 50.57,46.59 50.93,46.23 50.93,45.23 51.62,44.53 51.62,43.31 v2(51.16,42.85)
SIO_SLP_S4#: length 155.4
  TOP w0.127: R252.2 173.6,67 171.84,67 v2(171.64,67.2) ; v2(204.28,57.23) 204.05,57.46 UC8.1 ; UE5.B36 179.39,66.77 179.91,66.25 v2(180.06,66.25)
  IN1 w0.081: v2(180.06,66.25) 180.41,66.6 180.91,66.6 182.38,65.13 183.31,65.13 184.57,66.39 184.57,69.03 184.41,69.19 184.41,69.59 184.65,69.82 191.13,69.82 191.43,69.52 193.07,69.52 195.52,67.07 195.52,64.07 194.26,62.81 194.26,61.5 v2(193.81,61.05) 194.26,60.61 194.26,52.96 196.75,50.47 196.75,42.73 198.5,40.99 198.5,35.9 199.16,35.24 v2(199.16,34.38)
  IN2 w0.089: v2(171.64,67.2) 172.08,67.2 172.29,66.99 175.61,66.99 176.01,67.38 176.55,67.38 177.57,66.36 179.95,66.36 v2(180.06,66.25)
  IN3 w0.089: v2(144.02,47.67) 143.36,47.67 142.82,48.22 141.61,48.22 141.1,48.73 140.1,48.73 139.7,48.32 139.7,47.66 144.45,42.91 151.1,42.91 151.37,43.18 154.47,43.18 155.5,44.2 155.5,46.23 157.84,48.57 157.84,49.29 158.51,49.96 164.53,49.96 168.89,54.32 171.7,54.32 171.9,54.52 174.66,54.52 176.78,56.64 177.73,56.64 178.22,57.13 178.22,61.12 178.43,61.34 179.66,61.34 181.03,62.7 181.03,64.21 180.01,65.23 180.01,66.2 v2(180.06,66.25)
  IN4 w0.081: v2(204.28,57.23) 203.99,57.23 203.48,57.74 203.48,58.9 202.66,59.72 200.26,59.72 198.93,61.05 v2(193.81,61.05)
  BOTTOM w0.076: v2(144.02,47.67) 143.41,47.67 142.97,48.11 142.97,50.63 UCPU1.BA16
  BOTTOM w0.127: v2(199.16,34.38) 199.65,33.89 200.76,33.89 JAPS1.5
SIO_SLP_S5#: length 101.5
  TOP w0.127: v2(186.11,69.38) 185.86,69.13 185.86,68.72 UE5.A18
  IN3 w0.089: v2(144.04,47.08) 144.73,47.76 145.19,47.76 145.42,47.99 145.42,48.57 147.08,50.24 150.44,50.24 152.67,52.46 154.9,52.46 156.12,53.69 157.86,53.69 158.69,54.51 158.69,55.15 161.58,58.04 161.58,59.09 162.08,59.59 163.17,59.59 163.56,59.98 165.69,59.98 168.26,62.56 169.42,62.56 171.18,64.32 172.65,64.32 173.23,64.9 173.23,65.77 174.18,66.72 174.93,66.72 177.1,68.89 182.41,68.89 183.34,69.83 185.66,69.83 v2(186.11,69.38)
  IN4 w0.081: v2(199.96,34.39) 199.96,34.41 199.71,34.66
  IN4 w0.089: 199.71,34.66 197.5,36.88 196.63,36.88 196.3,37.21 196.3,49.75 194.03,52.02 194.03,54.81 191.71,57.13 191.71,57.91 190.68,58.94 190.68,62.17 187.76,65.09 187.76,66.37 186.54,67.59 186.54,68.94 v2(186.11,69.38)
  BOTTOM w0.076: UCPU1.AY16 142.95,51.12 142.64,50.81 142.64,50.39 142.81,50.22 142.81,47.95 143.68,47.08 v2(144.04,47.08)
  BOTTOM w0.127: JAPS1.4 200.76,34.39 199.97,34.39 v2(199.96,34.39)
SIO_SLP_SUS#: length 193.1
  TOP w0.127: PR801.1 172.19,79.41 v2(172.97,80.2) ; R1444.1 181.97,38 179.64,40.32 v2(179.64,40.57) ; UC13.1 199.51,59.09 199.75,59.33 203.05,59.33 203.64,58.74 v2(204.34,58.74) 204.34,59.23 201.49,62.08 201.49,63.57 201.92,64 201.92,65.32 201.63,65.61 198.52,65.61 197.67,64.77 194.59,64.77 v2(194.32,65.03) ; v2(176.73,55.7) 177.27,55.7 RC97.1 ; v2(153.26,47.23) 153.27,47.24 153.35,47.24 154.13,46.46 154.13,45.97 153.59,45.43 153.59,44.66 156.44,41.81 156.44,40.41 158.3,38.55 v2(158.3,38.01) 159.03,38.01 159.23,37.8 QE13.2
  IN1 w0.081: v2(172.97,80.2) 173.56,79.61 177.28,79.61 179.55,77.34 186.02,77.34 188.76,80.09 195.67,80.09 197.22,78.55 197.78,78.55 198.57,77.76 202.26,77.76 202.9,77.12 202.9,71.72 202.2,71.02 v2(202.2,71.01) ; v2(194.32,65.03) 194.02,65.03 193.72,64.74 192.61,64.74 192.5,64.85 190.72,64.85 190.25,64.37 189.69,64.37 189.56,64.25 188.57,64.25 188.06,63.73 182.47,63.73 180.09,61.36 178.4,61.36 175.84,58.8 175.84,58.04 176,57.88 176,56.47 176.73,55.74 v2(176.73,55.7) ; v2(143.51,55.01) 143.51,54.95 143.97,54.49 143.97,52.32 144.22,52.06 144.54,52.06 144.92,51.68 145.5,51.68 146.51,50.68 147.67,50.68 150.16,48.19 152.07,48.19 153.03,47.23 v2(153.26,47.23)
  IN2 w0.089: v2(176.73,55.7) 176.87,55.56 177.71,55.56 180.3,58.15 182.93,58.15 184,57.08 184,56.19 185.09,55.1 185.09,53.09 183.29,51.29 183.29,49.31 182.26,48.28 182.26,42.19 180.64,40.57 v2(179.64,40.57)
  IN3 w0.089: v2(179.64,40.57) 179.51,40.71 177.9,40.71 176.98,41.62 173.91,41.62 173.19,40.9 171.4,40.9 171.24,41.06 167.93,41.06 167.41,41.57 164.33,41.57 163.29,40.53 162.62,40.53 160.1,38.01 v2(158.3,38.01) ; v2(202.2,71.01) 202.2,70.99 203.51,69.69 203.51,67.01 203.35,66.86 203.35,59.72 v2(204.34,58.74)
  BOTTOM w0.127: PR700.2 204.34,59.32 v2(204.34,58.74) ; v2(202.2,71.01) 202.2,71.02 202.21,71.03 PR1412.1 ; UCPU1.AN15 143.58,55.01 v2(143.51,55.01)
SIO_SLP_SUS#_R: length 4.9
  TOP w0.127: UE5.B52 178.61,58.67 177.64,58.67 177.15,58.19 177.15,57.54 176.53,56.92 v3(176.53,56.75) 176.87,56.41 177.12,56.41 177.17,56.46 RC97.2
SIO_SLP_WLAN#: length 51.3
  TOP w0.127: v3(143.52,46.42) 143.64,46.3 v2(144.11,46.3) ; UE5.B45 178.88,62.27 v2(178.96,62.2)
  IN3 w0.089: v2(144.11,46.3) 144.35,46.54 146.2,46.54 146.89,47.23 146.89,47.63 148.4,49.15 150.76,49.15 152.52,50.9 157.45,50.9 159.58,53.03 159.58,54.82 161.8,57.04 165.67,57.04 166.63,58.01 166.63,59.05 167.3,59.71 170.77,59.71 171.67,58.82 172.52,58.82 173.61,59.9 173.61,61.8 174.33,62.52 178.63,62.52 v2(178.96,62.2)
  BOTTOM w0.127: v2(144.11,46.3) 143.9,46.3 142.38,47.82 UCPU1.BB17
SLEEVE:
  vias: v2(9.36,22.1) v2(9.95,22.11) v2(27.72,34.15) v2(27.77,33.55)
SLEEVE_R: length 20.3
  TOP w0.127: JHP1.3 6.62,25.09 6.62,24.54 v3(6.24,24.16)
  TOP w0.254: v2(18.47,27.01) 18.47,26.12 QA1.3
  IN1 w0.508: JHP1.3 6.62,24.89 7.42,24.09 7.42,23.25 7.75,22.92 10.99,22.92 11.59,22.31 15.98,22.31 18.42,24.75 18.42,26.96 v2(18.47,27.01)
SM_PG_CTRL: length 109.3
  TOP w0.127: v2(162.37,31.03) 162.54,31.2 PR609.1
  IN2 w0.089: v2(95.25,32.57) 95.25,32.04 94.34,31.12 94.34,29.32 95.56,28.1 95.56,27.39 97.87,25.08 98.61,25.08 98.61,25.08 98.79,25.08 99.61,24.26 99.61,22.64 104.01,18.23 105.61,18.23 106.95,19.57 117.18,19.57 118.85,17.91 125.06,17.91 126.57,19.41 131.58,19.41 132.74,18.25 156.31,18.25 158.26,20.2 161.65,20.2 162.95,21.5 162.95,26.82 162.15,27.62 162.15,28.28 162.8,28.93 162.8,30.59 v2(162.37,31.03)
  BOTTOM w0.127: v2(95.25,32.57) 95.63,32.95 95.63,33.56 95.38,33.81 95.38,35.2 99.42,39.23 99.42,42.17 v3(100.67,43.42) 101.4,44.15 RE60.2 101.76,44.9 102.84,44.9 UC2.4
SM_RCOMP0: length 4.6
  TOP w0.076: 140.77,52.59 140.82,52.59 141.25,53.02 141.25,53.3 v2(141.68,53.74)
  TOP w0.305: 140.77,52.59 139.88,51.7 139.88,51.22 139.55,50.89 RC5.1
  BOTTOM w0.254: UCPU1.AR18 142.12,54.08 v2(141.68,53.74)
SM_RCOMP1: length 3.6
  TOP w0.076: 141.15,52.18 141.15,52.57 v2(141.68,53.1)
  TOP w0.305: 141.15,52.18 v1(140.63,51.67) 140.44,51.47 RC6.1
  BOTTOM w0.254: v2(141.68,53.1) 142.12,53.43 UCPU1.AT18
SM_RCOMP2: length 2.6
  TOP w0.305: v2(141.68,52.47) 141.68,51.98 141.33,51.62 RC7.1
  BOTTOM w0.254: v2(141.68,52.47) 142.12,52.78 UCPU1.AU18
SML1_SMBCLK: length 41.8
  TOP w0.127: UE5.B6 187.21,61.77 186.93,61.77 186.61,61.45 v2(186.37,61.45)
  IN2 w0.089: v2(186.37,61.45) 186.18,61.64 181.09,61.64 180.98,61.52 178.4,61.52 177.98,61.1 177.98,60.33 177.15,59.51 174.88,59.51 174.04,60.35 174.04,60.98 172.63,62.38 172.28,62.38 171.73,61.83 169.67,61.83 168.86,62.65 166.75,62.65 165.65,63.75 163.14,63.75 162.95,63.56 156.11,63.56 155.42,62.87 v2(155.09,62.87)
  BOTTOM w0.076: v2(155.09,62.87) 155.07,62.9 153.85,62.9 153.4,62.44 152.02,62.44 151.88,62.38 151.75,62.38 151.52,62.45 151.52,62.45 151.39,62.45 151.17,62.37 151.02,62.37 150.82,62.17 UCPU1.W3
  BOTTOM w0.127: v2(155.09,62.87) 155.63,62.87 RC15.1
SML1_SMBDAT: length 45.9
  TOP w0.127: v3(154.07,63.7) 154.3,63.47 v2(155.06,63.47) ; UE5.A5 188.16,61.52 188.16,61.52 188.26,61.52 188.59,61.19 188.78,61.19 v2(188.79,61.2)
  IN2 w0.089: v2(155.06,63.47) 155.72,63.47 156.02,63.77 162.86,63.77 163.05,63.96 165.74,63.96 166.84,62.86 168.95,62.86 169.76,62.05 171.64,62.05 172.19,62.6 172.72,62.6 174.25,61.07 174.25,60.44 174.97,59.73 177.06,59.73 177.76,60.42 177.76,61.19 178.31,61.74 180.89,61.74 181,61.85 186.7,61.85 187.41,61.15 188.74,61.15 v2(188.79,61.2)
  BOTTOM w0.076: UCPU1.V3 150.76,62.57 151.23,62.57 151.36,62.61 151.55,62.61 151.57,62.6 151.77,62.55 151.85,62.55 151.98,62.6 153.27,62.6 154.14,63.47 v2(155.06,63.47)
  BOTTOM w0.127: v2(155.06,63.47) 155.3,63.71 RC17.1
SNB_1.0V: length 3.2
  BOTTOM w0.127: PC701.1 202.38,57.57 v1(202.85,57.1)
  BOTTOM w0.508: PC701.1 201.88,59.37 PR702.2
SNUB_1.8VA: length 1.5
  TOP w0.127: PR803.1 168.88,77.43 v1(168.62,77.69)
SNUB_1.8VU:
  vias: v3(166.6,44.79)
SNUB_1V_PRIM: length 1.1
  BOTTOM w0.508: PR1516.2 91.66,25.8 PC1519.1
SNUB_PRIM: length 2.7
  TOP w0.127: PC1419.1 196.44,70.2 v3(195.86,69.61)
  TOP w0.508: PC1419.1 196.44,71.84 196.57,71.97
SNUB_VCC_EDRAM: length 3.1
  BOTTOM w0.127: PC1510.1 95.22,37.68 v1(96.57,37.68)
  BOTTOM w0.508: PC1510.1 93.76,37.17 PR1505.2
SNUB_VCCIO: length 2.6
  TOP w0.127: v1(167.85,47.06) 168,47.2 PR1403.2
  TOP w0.508: PC1410.1 168,48.15 PR1403.2
SPI_CLK_VROM: length 11.8
  BOTTOM w0.127: RC29.2 183.79,56.14 183.55,55.9 183.1,55.9 182.47,55.28 U18.6 182.47,53.88 182.3,53.7 181.88,53.7 181.05,52.87 180.91,52.87 180.7,52.65 180.7,49.89 180.16,49.35 180.16,48.98 179.64,48.47 v1(179.41,48.47) 178.69,48.47 178.44,48.21 RP5.2
SPI_IO2_VROM: length 12.9
  BOTTOM w0.127: RP6.3 178.27,44.92 178.47,45.13 178.84,45.13 179,44.97 179,44.8 179.12,44.67 183.16,44.67 183.32,44.83 v1(183.32,45.05) 183.32,45.53 183.45,45.65 184.04,45.65 184.18,45.8 184.18,46.01 184.03,46.16 183.45,46.16 183.32,46.29 183.32,46.41 183.19,46.53 182.99,46.53 182.81,46.36 182.81,45.19 182.66,45.05 182.45,45.05 182.3,45.19 182.3,46.27 182.47,46.44 U18.3
SPI_IO3_VROM: length 24.4
  BOTTOM w0.127: U18.7 183.74,53.68 184.31,53.11 185.13,53.11 185.45,52.79 185.45,49.64 185.76,49.34 187.73,49.34 189.47,47.6 189.47,46.97 189.2,46.69 187.77,46.69 v1(187.23,46.15) 185.9,44.82 183.88,44.82 183.48,44.42 RP6.4
SPI_SI_VROM: length 13.2
  BOTTOM w0.127: RP5.1 178.36,48.71 178.47,48.83 179.64,48.83 179.9,49.09 179.9,49.46 180.44,50 180.44,51.87 178.57,53.74 178.57,54.3 v1(178.76,54.49) 178.95,54.67 179.33,54.67 180.75,53.25 181.07,53.25 181.2,53.38 U18.5
SPI_SO_VROM: length 13.1
  BOTTOM w0.127: RP6.2 179.11,45.42 179.21,45.32 179.21,45.12 179.33,44.99 179.76,44.99 179.89,45.12 179.89,45.57 180.02,45.69 180.2,45.69 180.33,45.56 180.33,45.15 180.46,45.02 180.64,45.02 180.77,45.15 180.77,45.68 180.92,45.83 181.13,45.83 181.28,45.68 v1(181.28,45.4) 181.28,45.15 181.43,45 181.8,45 182,45.2 182,45.76 181.65,46.11 181.65,46.46 181.84,46.66 181.84,48.15 181.99,48.3 183.61,48.3 183.74,48.17 U18.2
SPK_L+_C:
  vias: v2(22.58,16.09) v2(23.22,16.09) v3(21.82,18.5)
SPK_L-_C:
  vias: v2(24.15,14.71) v2(24.29,15.28) v3(25.04,15.5)
SPK_OUT_L+: length 1.5
  TOP w0.203: v2(27.36,25.15) 27.46,25.26 27.46,26.63
  vias: v2(24.52,21.45) v2(24.51,20.84) v2(26.94,24.74)
SPK_OUT_L-:
  vias: v3(26.57,21.93)
SPK_OUT_R+:
  vias: v3(30.15,23.66)
SPK_OUT_R-:
  vias: v3(28.68,22.18)
SPK_R+_C:
  vias: v2(28.87,14.71) v2(29.46,14.74) v3(30.63,17.08)
SPK_R-_C: length 0.9
  TOP w0.127: v2(26.9,14.82) v3(26.9,13.94)
  vias: v2(27.49,14.82)
SPKR: length 217.9
  TOP w0.127: v2(27.01,39.35) 26.95,39.35 v1(26.59,39) 26.29,38.69 RA25.1 ; RC183.2 149.89,52.47 v2(149.86,52.49)
  IN3 w0.089: v2(42.11,25.82) 40.99,26.94 37.85,26.94 37.58,26.67 36.59,26.67 35.94,27.31 35.94,36.32 33.27,38.99 32.67,38.99 32,39.66 32,40.19 31.37,40.82 28.48,40.82 v2(27.01,39.35)
  IN4 w0.081: v2(42.11,25.82) 42.39,25.54 42.39,23.51 43.81,22.1 43.81,20.69 44.4,20.1 49.33,20.1 50.47,21.23 53.29,21.23 53.34,21.18 54.01,21.18 54.23,21.4 56.63,21.4 59.13,18.9 62.02,18.9 64.07,20.94 66.19,20.94 69.54,24.29 69.54,25.48 71.74,27.68 74.2,27.68 77.02,30.5 77.87,30.5 78.97,31.6 82.74,31.6 84.56,33.42 85.88,33.42 86.38,33.92 86.38,34.61 86.73,34.96 89.83,34.96 90.64,34.15 95.37,34.15 96.2,33.32 96.2,29.91 97.02,29.09 97.02,25.36 97.11,25.27 97.11,23.09 97.67,22.52 99.5,22.52 101.52,20.5 106.52,20.5 107.03,19.99 123.38,19.99 123.78,19.59 144.74,19.59 145.24,20.1 147.4,20.1 147.8,19.69 160.77,19.69 164.68,23.61 164.68,34.01 163.66,35.03 163.66,36.32 162.98,37 162.98,37.01 162.32,37.66 161.08,37.66 157.33,41.41 157.33,43.87 156.36,44.85 156.36,45.66 155.44,46.57 155.44,47.25 155.44,47.91 155.07,48.28 154.47,48.28 154.34,48.41 152.41,48.41 149.84,50.99 149.84,52.46 149.87,52.49 v2(149.86,52.49)
  BOTTOM w0.127: v2(149.86,52.49) 149.87,52.49 149.58,52.21 UCPU1.AW5
SRTCRST#: length 16
  TOP w0.127: RC56.1 147.17,45.55 CC24.1 147.52,46.67 v2(147.8,46.67)
  IN2 w0.089: v2(141.68,55.01) 141.75,55.01 142.14,54.62 142.14,52.41 143.66,50.89 146.1,50.89 148.18,48.8 148.18,47.06 v2(147.8,46.67)
  BOTTOM w0.076: UCPU1.AN18 v2(141.68,55.01)
  BOTTOM w0.127: v2(147.8,46.67) 147.37,46.67 v3(146.98,47.06)
SS_1.8VA: length 7.7
  TOP w0.127: PC806.1 176.74,74.25 177.25,73.74 177.87,73.74 178,73.87 178,75.13 178.57,75.7 179.46,75.7 179.86,76.1 v3(179.86,76.68)
  TOP w0.254: PC806.1 176.61,74.28 174.66,74.28 PU800.9
SS_1.8VU: length 3
  TOP w0.203: PU900.9 170.33,41.38 170.47,41.25 v2(170.47,39.81) 170.47,39.08 PC906.1
SS_1V_PRIM: length 3.9
  TOP w0.127: v3(85.16,26.18) 85.54,26.57 v2(85.54,27.37)
  BOTTOM w0.254: PC1520.1 84.56,26.63 85.07,27.14 85.31,27.14 v2(85.54,27.37) 85.9,27.72 PU1501.7
SS_PRIM: length 2.7
  TOP w0.203: PU1401.7 200.28,72.07 v2(200.38,71.97)
  BOTTOM w0.127: v3(200.86,71.49) v2(200.38,71.97)
  BOTTOM w0.203: PC1420.1 200.38,72.65 v2(200.38,71.97)
SS_VCC_EDRAM: length 3.1
  TOP w0.127: v2(88.6,36.56) 88.6,37.37 v3(88.54,37.42)
  TOP w0.254: v2(88.6,36.56) 88.39,36.36 88.14,36.36 87.73,35.95 PC1511.1
  BOTTOM w0.254: PU1500.7 89.06,37.36 89.06,36.95 88.75,36.64 88.67,36.64 v2(88.6,36.56)
SS_VCCIO: length 1.7
  TOP w0.203: PC1411.1 174.72,46.82 PU1400.7
SSD_DEVSLP: length 73.9
  TOP w0.127: v2(174.43,32.59) 174.52,32.67 R1376.2
  IN2 w0.089: v2(152.43,67.93) 152.43,67.9 153.24,67.09 153.24,66.28 153.44,66.07 154.32,66.07 155.39,65.01 155.39,64.6 155.1,64.32 154.91,64.32 154.26,63.67 154.26,62.79 154.8,62.25 156.63,62.25 157.89,60.99 163.61,60.99 165.14,59.47 170.59,59.47 171.43,58.63 172.26,58.63 172.46,58.82 173.2,58.82 175.1,56.93 175.1,53.29 174.9,53.09 174.9,51.71 175.53,51.08 177.52,51.08 180.13,53.69 180.76,53.69 181.61,52.84 181.61,45.29 180.48,44.15 177.01,44.15 176.63,43.77 176.63,43.06 176.24,42.67 176.24,40.92 175.88,40.56 175.88,37.74 175.22,37.08 175.22,33.17 174.64,32.59 v2(174.43,32.59)
  BOTTOM w0.127: JNGFF2.38 175.6,32.55 174.48,32.55 v2(174.43,32.59) ; v2(152.43,67.93) 152.32,67.83 151.17,67.83 UCPU1.J3
SSD_IFDET: length 80.8
  TOP w0.127: RC51.2 151.14,67.19 151.99,66.33 152.62,66.33 153.1,66.81 153.1,67.91 153.64,68.45 154.13,68.45 154.55,68.03 156.56,68.03 157.14,68.62 159.62,68.62 160.48,69.47 161.61,69.47 v2(162.2,68.88)
  IN4 w0.081: v2(156.41,72.86) 156.41,72.5 158.52,70.39 159.82,70.39 160.6,69.62 161.47,69.62 v2(162.2,68.88) 162.2,68.64 165.63,65.21 165.63,64.37 167.56,62.44 167.56,60.77 168.68,59.65 168.68,57.81 171.78,54.71 171.78,53.43 172.54,52.66 172.54,48.46 173.65,47.36 173.65,46.17 174.55,45.26 174.55,41.24 177.52,38.26 v2(178.46,38.26)
  BOTTOM w0.127: UCPU1.G4 150.48,68.49 152.68,68.49 153.85,69.66 153.85,70.68 155.08,71.92 R2665.1 155.68,72.44 156.1,72.86 v2(156.41,72.86) ; v2(178.46,38.26) 184.38,38.26 184.63,38.52 v3(185.4,38.52) 187.12,38.52 187.99,39.38 187.99,40.12 188.5,40.63 U683.4
SSD_PCIE_WAKE#: length 6.8
  TOP w0.127: R1377.1 175.79,36.01 176.87,36.01 177.11,35.76 177.36,35.52 177.77,35.52 v3(177.78,35.53) v2(178.28,36.03)
  BOTTOM w0.127: v2(178.28,36.03) 177.94,35.68 177.09,35.68 176.23,36.54 175.6,36.54 JNGFF2.54
SSD_PWR_EN: length 79.7
  TOP w0.127: R1188.2 R1446.1 178.19,35.06 177.46,35.06 176.76,35.75 174.08,35.75 173.75,35.43 171.87,35.43 171.37,34.92 171.37,34.06 170.92,33.61 v2(170.92,33.36)
  IN2 w0.089: v2(170.92,33.36) 168.93,35.35 168.93,37.95 167.82,39.06 167.82,40.16 168.47,40.82 168.47,43.1 168.65,43.29 168.65,47.39 167.26,48.78 167.26,50.43 166.64,51.05 166.64,55.43 v2(163.42,58.65)
  IN4 w0.081: v2(158.52,56.65) 157.68,57.49 157.68,58.03 157.34,58.37 157.01,58.37 155.75,59.64 154.73,59.64 154.49,59.41 154.49,56.56 155.29,55.77 155.29,51.32 155.01,51.04 154.79,51.04 154.48,51.35 154.48,51.35 154.48,52.01 154,52.49 153.34,52.49 151.13,54.7 151.13,57.15 150.21,58.07 149.41,58.07 148.35,59.13 146.27,59.13 145.83,59.57 v2(145.79,59.57)
  BOTTOM w0.076: v2(145.79,59.57) 145.85,59.63 145.85,60.21 146.48,60.84 146.48,62.39 146.33,62.54 145.72,62.54 145.49,62.31 UCPU1.W12
  BOTTOM w0.127: v2(158.52,56.65) 159.04,56.65 161.04,58.65 v2(163.42,58.65)
SUS_ON_EC: length 62.4
  TOP w0.127: UC8.2 203.4,57.66 203.05,57.31 202.44,57.31 202.18,57.57 RE95.2 201.55,57.57 v2(200.84,58.28) ; R252.1 RE68.1 173.2,68.68 174.67,70.15 v2(174.75,70.15) ; v2(193.07,52.6) 193.07,53.5 193.87,54.3 193.87,60.39 194.23,60.75 194.23,62.41 193.78,62.87 191.52,62.87 R251.1 191.68,63.19 192.38,63.19 192.61,63.43 192.61,63.85 192.79,64.03 192.79,64.99 192.25,65.52 192.25,65.76 191.83,66.18 190.53,66.18 189.94,66.77 189.94,68.2 189.56,68.58 189.56,68.91 189.31,69.16 189.31,69.52 189.66,69.88 189.66,70.94 v2(189.99,71.26)
  IN1 w0.081: v2(174.75,70.15) 175.19,70.58 177.4,70.58 177.87,71.06 178.26,71.06 179,71.8 181.55,71.8 182.67,72.92 184.19,72.92 185.33,71.78 189.47,71.78 v2(189.99,71.26)
  BOTTOM w0.127: v2(200.84,58.28) 200.84,56.45 201.16,56.13 201.16,54.15 199.53,52.51 197.79,52.51 197.32,52.05 v3(194.05,52.05) 193.63,52.05 v2(193.07,52.6)
SUS_ON_P: length 401.5
  TOP w0.127: UZ23.4 50.73,51.48 51.37,51.48 v2(51.79,51.06) ; PR900.1 173.53,43.06 175.59,43.06 177.36,41.29 v2(178.48,41.29) ; PR607.1 166.5,34.1 166.5,34.81 165.81,35.5 v2(165.75,35.5) ; UC8.4 202.2,56.13 RE95.1 RE97.1 v2(200.71,55.81) 199.92,56.6 199.49,56.6 198.86,57.24 198.86,57.49 UC13.2 ; v2(175.11,80.12) 174.66,80.56 173.67,80.56 173.48,80.37 173.48,79.92 173.08,79.51 PR800.1
  IN1 w0.081: v2(175.11,80.12) 177.06,80.12 179.63,77.55 185.93,77.55 188.67,80.29 195.76,80.29 197.3,78.75 197.87,78.75 198.65,77.97 202.38,77.97 203.24,77.11 203.24,70.44 199.24,66.44 199.24,57.28 v2(200.71,55.81)
  IN3 w0.089: v2(178.48,41.29) 178.74,41.03 179.77,41.03 180.09,40.71 180.09,40.37 179.89,40.16 179.25,40.16 178.93,40.49 177.81,40.49 176.89,41.4 174,41.4 173.28,40.68 171.31,40.68 171.15,40.84 167.84,40.84 167.32,41.36 164.45,41.36 163.95,40.86 163.95,39.54 164.21,39.29 164.8,39.29 165.03,39.52 v2(165.03,39.6) ; v2(165.75,35.5) 165.75,35.49 165.72,35.49 166.4,34.81 166.4,29.32 165.1,28.02 165.1,24.26 158.97,18.13 158.97,16.36 159.67,15.66 162.16,15.66 163.34,16.84 174.33,16.84 177.04,19.55 177.04,20.46 178.71,22.13 181.24,22.13 185.98,26.87 185.98,31.92 188,33.94 201.17,33.94 202.26,35.04 202.26,46.09 199.31,49.03 199.31,51.95 201.14,53.78 201.14,55.38 v2(200.71,55.81)
  IN4 w0.081: v2(51.79,51.06) 50.42,51.06 47.22,47.86 47.22,46.41 41.05,40.24 41.05,40.01 40.64,39.61 39.34,39.61 36.91,37.17 36.91,35.46 38.12,34.25 38.12,33.06 39.81,31.38 39.81,28.04 41.48,26.37 41.48,25 40.44,23.96 40.44,22.97 41.45,21.95 41.45,21.14 41.69,20.91 42.03,20.91 43.76,19.17 45.51,19.17 46.58,18.1 48.65,18.1 50.85,20.3 52.91,20.3 52.95,20.26 54.39,20.26 54.61,20.47 56.04,20.47 59.13,17.39 62.81,17.39 63.67,18.24 67,18.24 67.85,19.1 67.85,21.13 73.04,26.32 75.61,26.32 79.21,29.92 81.64,29.92 81.98,29.58 83.72,29.58 85.69,31.56 87.48,31.56 88.29,32.37 91.85,32.37 92.57,31.64 92.57,31.04 94.14,29.47 95.45,29.47 96.18,28.75 96.18,25.03 96.27,24.93 96.27,22.74 97.33,21.69 99.16,21.69 101.18,19.67 106.18,19.67 106.69,19.16 123.04,19.16 123.44,18.76 145.09,18.76 145.59,19.26 147.06,19.26 147.46,18.86 161.12,18.86 165.52,23.27 165.52,27.8 166.42,28.69 166.42,34.83 v2(165.75,35.5) 165.18,36.08 165.18,39.45 v2(165.03,39.6)
SUSACK#: length 66
  TOP w0.127: UE5.B7 187.03,62.27 186.62,61.87 185.97,61.87 v2(185.57,62.26)
  IN3 w0.089: v2(185.57,62.26) 185.31,62.52 185.31,63.49 185.53,63.71 186.74,63.71 188.11,65.08 188.11,66.23 188.46,66.57 188.94,66.57 189.19,66.82 189.19,68.92 187.56,70.55 184.13,70.55 183.65,71.04 179.29,71.04 178.89,70.65 176.77,70.65 171.97,65.85 171.51,65.85 170.85,65.19 169.12,65.19 167.76,63.82 163.69,63.82 162.5,62.63 162.5,61.54 161.67,60.72 160.35,60.72 160.12,60.49 160.12,60.23 157.75,57.85 157.75,57.12 157.3,56.68 156.85,56.68 156.29,57.23 154.8,57.23 154.22,56.64 152.56,56.64 152.3,56.9 150.5,56.9 150.12,56.52 146.55,56.52 145.85,55.83 145.85,54.78 v2(146.25,54.37)
  BOTTOM w0.127: UCPU1.AP11 145.88,54.75 v2(146.25,54.37)
SUSCLK: length 187.4
  TOP w0.127: v2(42.19,47.48) 42.37,47.48 43,46.85 R1255.2 ; R2662.2 173.76,42.01 173.16,41.41 v2(173.05,41.41)
  IN2 w0.089: v2(42.19,47.48) 43.49,46.19 43.49,37.12 44.17,36.43 44.63,36.43 45.28,35.78 45.28,35.05 44.03,33.8 42.39,33.8 41.52,32.94 41.52,32.25 42.3,31.47 43.75,31.47 44.44,32.15 46.14,32.15 53.45,24.84 55.59,24.84 56.12,24.3 58.1,24.3 60.11,26.31 63.16,26.31 64.52,27.67 76.1,27.67 77.57,29.14 v2(79.43,29.14)
  IN4 w0.081: v2(79.43,29.14) 79.68,28.89 80.5,28.89 80.88,29.26 81.41,29.26 81.72,28.96 87.02,28.96 89,30.93 91.42,30.93 91.69,30.66 92.07,30.66 95.16,27.57 95.16,26.92 94.57,26.33 v2(94.57,26.16)
  BOTTOM w0.076: RC48.1 145.54,45.42 144.3,46.67 143.84,46.67 142.64,47.86 142.64,49.87 142.38,50.13 UCPU1.BA17
  BOTTOM w0.127: 145.55,43.33 143.13,40.9 139.37,40.9 v3(138.74,40.28) 136.86,38.39 118.23,38.39 117.22,39.4 106.2,39.4 103.83,37.04 102.09,37.04 99.48,34.43 99.48,34.11 99.08,33.71 98.22,33.71 97.7,33.19 97.7,31.96 96.97,31.23 96.97,28.78 94.57,26.37 v2(94.57,26.16) ; 145.55,43.33 148.08,40.8 153.97,40.8 154.41,41.24 154.41,41.81 155,42.4 158.67,42.4 159.08,42 162.06,42 162.38,42.31 166.03,42.31 167.38,40.96 172.6,40.96 v2(173.05,41.41) ; 145.55,43.33 145.55,44.95 RC48.1
SYS_RESET#: length 117.1
  TOP w0.127: v2(152.01,72.73) 152.01,71.8 RC291.2 RC224.2 153.52,69.83 153.21,69.53 153.21,68.97 153.48,68.7 154.24,68.7 154.66,68.28 156.45,68.28 157.04,68.87 159.52,68.87 160.76,70.11 162.77,70.11 163.51,69.37 v2(163.57,69.37)
  IN1 w0.081: v2(163.57,69.37) 163.64,69.3 166.06,69.3 167.62,70.87 167.62,73.38 170.79,76.54 175.95,76.54 176.23,76.27 187.49,76.27 189.13,77.91 196.66,77.91 196.87,77.7 197.43,77.7 198.22,76.92 201.91,76.92 202.05,76.77 202.05,73.33 201.07,72.35 201.07,69.46 196.01,64.4 196.01,62.89 194.68,61.55 194.68,53.14 197.79,50.02 197.79,48.01 196.96,47.18 196.96,42.82 198.7,41.07 198.7,36.08 199.57,35.21 199.57,30.39 v2(199.95,30.01)
  BOTTOM w0.076: v2(152.01,72.73) 152.01,72.72 151.28,71.99 150.8,71.99 150.47,71.66 UCPU1.B5
  BOTTOM w0.127: v2(199.95,30.01) 200.07,29.89 200.76,29.89 JAPS1.13
SYS_RESET#_R: length 7.5
  TOP w0.127: RC290.2 155.52,70.18 155.79,70.45 155.79,71.36 155.47,71.68 UC12.4 154.9,72.25 153.68,72.25 RC224.1 154.02,71.59 154.02,70.75 153.85,70.57 153.85,69.38 v3(153.67,69.2)
SYSTEM_WAKE#: length 4.5
  TOP w0.127: R1439.2 29.47,60.03 30.66,60.03 QT19.3 31.29,58.51 R1462.2
TBT_AUX_N: length 57.1
  TOP w0.076: U722.J2 21.76,63.72 20.89,63.72 20.67,63.95 20.32,63.95 19.38,64.89 v2(19.31,64.89)
  TOP w0.127: v2(19.31,64.89) 19.26,64.85 18.84,64.85 R1478.2 ; v2(53.37,64.7) 53.37,64.49 52.97,64.09 CT42.2
  IN3 w0.089: v2(53.37,64.7) 53.37,64.68 53.16,64.47 53.16,64.41 52.92,64.18 52.86,64.18 52.73,64.04 52.53,64.04 51.93,63.44 51.93,61.62 51.66,61.35 51.66,59.91 50.86,59.1 50.32,59.1 49.85,58.63 49.85,53.76 49.42,53.32 49.12,53.32 48.43,52.62 47.68,52.62 47.18,53.12 41.83,53.12 39.54,55.42 34.22,55.42 33.56,56.08 31.26,56.08 30.36,56.98 29.35,56.98 29.01,57.33 26.88,57.33 25.38,58.84 24.96,58.84 23.97,59.83 23.46,59.83 23.15,60.13 23.15,60.63 22.76,61.02 19.62,61.02 19.05,61.59 19.05,64.64 v2(19.31,64.89)
TBT_AUX_N_C: length 7.7
  TOP w0.127: v2(45.42,62.15) 45.75,61.82 UT1.W15 ; v2(48.64,64.3) 50.62,64.3 50.7,64.38 51.25,64.38 CT42.1
  BOTTOM w0.127: v2(45.42,62.15) 45.42,62.18 46.37,63.13 47.07,63.13 47.63,63.69 48.19,63.69 48.64,64.14 v2(48.64,64.3)
TBT_AUX_P: length 53.2
  TOP w0.127: v2(52.76,64.58) 52.6,64.73 CT41.2 ; U722.J1 22.01,64.47 22.01,65.05 v2(21.88,65.18) 21.18,65.87 R1472.2
  IN3 w0.089: v2(21.88,65.18) 22.73,64.32 22.73,63.12 24.78,61.08 25.28,61.08 25.94,60.42 25.94,59.2 26.76,58.38 26.77,58.38 27.18,57.97 29.27,57.97 29.54,57.71 32.39,57.71 33.34,58.66 35.58,58.66 35.98,58.26 35.98,57.71 36.44,57.26 36.44,55.95 36.76,55.63 42.29,55.63 42.98,54.95 42.98,53.6 43.24,53.34 47.27,53.34 47.77,52.84 48.34,52.84 49.03,53.54 49.33,53.54 49.63,53.85 49.63,58.72 50.23,59.32 50.77,59.32 51.45,59.99 51.45,61.44 51.71,61.71 51.71,63.53 v2(52.76,64.58)
  BOTTOM w0.127: v1(21.27,65.19) 21.28,65.18 v2(21.88,65.18)
TBT_AUX_P_C: length 9.1
  TOP w0.127: UT1.Y15 46.4,61.88 46.14,62.14 v2(46.08,62.14) ; CT41.1 v2(51.54,65.64)
  BOTTOM w0.127: v2(46.08,62.14) 46.58,62.65 49.33,62.65 49.68,63 49.68,63.89 50.17,64.37 50.66,64.37 51.03,64.74 51.03,65.13 v2(51.54,65.64)
TBT_BATLOW#: length 2.6
  TOP w0.076: 39.52,55.15 39.52,55.7 UT1.F2
  TOP w0.127: RT25.2 39.44,53.62 v1(39.44,54.31) 39.44,54.52 39.52,54.6 39.52,55.15
TBT_CC1: length 18.9
  TOP w0.203: 21.01,60.47 21.51,60.47 U722.K9 ; 21.01,60.47 20.89,60.47 19.51,59.09 v2(19.51,58.96) ; 21.01,60.47 U722.L9 ; 9.12,61.54 9.13,61.55
  TOP w0.254: v2(14.8,61.34) 15.04,61.1 C1279.1 15.8,61.11 D77.1 14.56,61.9 14.5,61.96 13.45,61.96 13.31,62.11 12.57,62.11 11.63,61.17 10.21,61.17 9.83,61.55 9.13,61.55 ; JUSBC1.A5 9.12,61.54 9.12,61.54
  IN3 w0.254: v2(14.8,61.34) 15.96,60.17 17.81,60.17 19.03,58.96 19.53,58.96 v2(19.51,58.96)
TBT_CC2: length 24.8
  TOP w0.203: JUSBC1.B5 3.91,58.48 3.91,55.71 4.29,55.33 9.61,55.33 9.86,55.57 10.35,55.57 D86.1 11.04,56.26 12.39,56.26 v3(13,56.87) 14.33,56.87 C1280.1 17.11,57.25 17.98,58.12 19.41,58.12 20.31,59.03 20.31,59.41 20.87,59.97 21.01,59.97 U722.L10 U722.K10
TBT_CIO_PLUG_EVENT#: length 249.4
  TOP w0.076: UT1.W2 45.94,55.7 45.94,54.39 45.97,54.36
  TOP w0.102: 150.14,62.17 149.61,62.17 149.22,61.78 149.22,61.71 148.63,61.12 146.22,61.12 v2(145.82,60.71)
  TOP w0.127: 45.97,54.36 46.06,54.27 v2(46.06,54) 46.2,53.85 RT23.2 ; 150.14,62.17 150.27,62.17 150.36,62.08 152.35,62.08 v2(152.63,61.81)
  IN2 w0.089: v2(152.63,61.81) 152.97,61.81 154.4,60.37 155.38,60.37 157.14,58.61 157.44,58.61 158.15,57.9 158.15,57.77 158.6,57.32 164.14,57.32 166.21,55.25 166.21,50.87 166.83,50.25 166.83,48.6 166.39,48.17 166.39,42.76 166.8,42.36 166.8,40.69 166.73,40.62 166.73,39.53 168.49,37.77 168.49,34.86 166.76,33.13 166.76,27.13 165.79,26.16 165.79,19.82 163.4,17.44 159.68,17.44 156.89,14.64 132.58,14.64 130.47,16.75 127.68,16.75 125.57,14.64 117.93,14.64 116.47,16.09 115.74,16.09 114.93,16.91 108.76,16.91 107.6,15.75 101.61,15.75 100.21,17.15 96.96,17.15 96.06,18.04 88.29,18.04 v2(87.78,18.55) ; v2(46.06,54) 45.56,53.5 44.96,53.5 44.68,53.22 43.55,53.22 42.92,52.6 42.92,51.84 43.37,51.39 43.37,50.14 42.86,49.63 42.33,49.63 41.26,48.56 41.26,47.09 39.84,45.67 39.84,37.21 41.42,35.63 41.42,34.34 39.94,32.86 39.61,32.86 39.23,32.48 39.23,31.59 39.41,31.42 39.41,30.7 38.74,30.03 38.23,30.03 37.66,29.46 37.66,23.22 37.31,22.88 37.31,22.16 37.53,21.94 37.99,21.94 39.54,20.39 50.95,20.39 51.49,20.93 61.15,20.93 65.76,25.54 79.86,25.54 v2(79.91,25.59)
  IN3 w0.089: v2(79.91,25.59) 79.91,25.1 80.32,24.7 80.32,18.9 81.56,17.66 86.86,17.66 87.76,18.55 v2(87.78,18.55)
  BOTTOM w0.127: v2(145.82,60.71) 145.49,61.05 UCPU1.AB12
TBT_DBG_CTL1: length 5.7
  TOP w0.127: v2(27.33,63.16) 27.63,63.46 R1454.2 ; U722.E4 24.01,62.97 24.01,63.37 v2(23.95,63.43)
  IN2 w0.089: v2(23.95,63.43) 23.95,63.68 24.26,63.99 25.35,63.99 26.16,63.18 27.3,63.18 v2(27.33,63.16)
TBT_DBG_CTL2: length 5.9
  TOP w0.076: U722.D5 24.61,62.57 24.71,62.57 v2(25.02,62.87)
  TOP w0.127: R1460.2 27.75,62.57 v2(27.65,62.67)
  IN2 w0.089: v2(25.02,62.87) 25.65,62.87 26.17,62.36 26.76,62.36 26.93,62.19 27.29,62.19 27.65,62.55 v2(27.65,62.67)
  BOTTOM w0.127: v1(26.16,62.38) 25.66,62.87 v2(25.02,62.87)
TBT_DDC_CLK: length 3
  TOP w0.076: 46.4,55.12 46.4,55.7 UT1.Y2
  TOP w0.127: 46.4,55.12 46.4,54.7 46.79,54.32 46.79,54.15 47.47,53.47 RT33.2
TBT_DDC_DATA: length 2.3
  TOP w0.076: 46.18,55.08 UT1.Y1
  TOP w0.127: RT34.2 46.53,53.77 46.53,54.14 46.18,54.49 46.18,55.08
TBT_DEBUG3: length 4.6
  TOP w0.076: U722.L3 20.89,63.47 20.6,63.76 20.25,63.76 20.13,63.88
  TOP w0.127: 20.13,63.88 19.97,64.04 v3(19.7,64.04) 18.98,64.04 RT188.1 18.42,64.25 17.32,64.25 R1463.2
TBT_DEBUG4: length 8
  TOP w0.076: U722.K3 21.27,63.23 20.9,63.23 20.54,63.6 20.14,63.6 20.1,63.64 19.7,63.64
  TOP w0.127: v3(15.28,64.76) 15.28,64.37 16.32,63.33 R1464.2 16.45,63.21 16.91,62.74 18.24,62.74 RT187.1 18.95,63.31 19.28,63.64 19.7,63.64
TBT_FORCE_PWR: length 263.8
  TOP w0.127: v2(44.32,50.28) 44.32,50.65 RT38.2 ; RC247.2 148.64,71.87 150.96,71.87 151.57,72.47 151.57,73.01 151.8,73.25 155.84,73.25 v2(155.98,73.39) ; v2(95.12,25.46) 94.41,24.75 93.36,24.75 93.02,25.09 v1(92.61,25.09) 89.46,25.09 88.77,25.77 84.65,25.77 84.05,26.37 84.05,27.72 83.81,27.96 83.2,27.96 82.37,27.14 82.37,26.49 80.73,24.85 79.6,24.85 78.75,25.71 v2(78.75,26.39) ; UT1.H4 40.24,56.93 v2(40.24,56.93)
  IN1 w0.081: v2(155.98,73.39) 156.02,73.35 156.02,66.56 154.4,64.94 154.4,62.57 155.54,61.43 155.54,56.61 154.15,55.22 154.15,54.48 v2(154.2,54.43)
  IN2 w0.089: v2(44.32,50.28) 43.84,50.28 42.96,49.41 42.42,49.41 41.48,48.47 41.48,47 40.06,45.58 40.06,37.3 41.63,35.72 41.63,34.25 40.03,32.65 39.7,32.65 39.45,32.39 39.45,31.68 39.62,31.5 39.62,29.9 38.94,29.22 38.18,29.22 37.87,28.91 37.87,23.13 37.53,22.79 37.53,22.4 37.72,22.21 38.51,22.21 40.06,20.66 50.91,20.66 51.51,21.26 54.56,21.26 54.74,21.43 61.27,21.43 65.59,25.75 78.1,25.75 v2(78.75,26.39) ; v2(95.12,25.46) 95.58,25.46 96.33,24.71 97.52,24.71 98.77,23.47 98.77,22.36 103.62,17.51 105.91,17.51 107.04,18.63 108.11,18.63 115.65,18.63 116.46,17.82 117.19,17.82 118.65,16.37 124.85,16.37 126.57,18.09 126.57,18.09 126.96,18.47 131.19,18.47 132.18,17.48 156.7,17.48 158.55,19.34 161.87,19.34 163.96,21.42 163.96,30.51 162.11,32.37 162.11,35.44 160.63,36.92 160.63,39.23 160.93,39.53 160.93,42.11 162.41,43.59 162.41,46.16 161.5,47.07 158.8,47.07 158.42,46.69 157.19,46.69 156.23,47.65 156.23,48.29 154.89,49.63 154.28,49.63 153.76,49.11 152.79,49.11 152,49.9 152,52.7 152.91,53.61 153.57,53.61 154.2,54.23 v2(154.2,54.43)
  BOTTOM w0.127: v2(40.24,56.93) 38.6,55.29 38.6,53.93 38.81,53.72 39.47,53.72 40.41,52.78 41.38,52.78 42.03,52.13 42.03,51.7 43.2,50.53 44.08,50.53 v2(44.32,50.28)
TBT_HPD: length 26.4
  TOP w0.127: v2(42.17,56.95) 42.16,56.95 UT1.M4 ; R1437.2 28.7,58.64 v1(29.46,57.88) 29.78,57.88 v2(30.12,58.23) ; RT43.2 45.82,52.08 v2(45.73,52.17)
  IN3 w0.089: v2(42.17,56.95) 42.17,56.47 41.54,55.85 38.15,55.85 36.2,57.8 36.2,58.35 34.7,59.85 31.75,59.85 v2(30.12,58.23)
  BOTTOM w0.127: v2(45.73,52.17) 44.85,53.04 42.65,53.04 41.94,53.76 41.94,56.72 v2(42.17,56.95)
TBT_I2C_B_N: length 10.9
  TOP w0.076: U722.L7 20.97,61.44 20.18,61.44 18.99,60.25 18.28,60.25 18.24,60.2 18.22,60.2
  TOP w0.127: v2(13.62,61.43) 13.96,61.08 13.96,60.72 14.24,60.44 14.48,60.2 v4(16.76,60.2) 18.22,60.2
  BOTTOM w0.127: ML7.4 12.89,60.54 12.99,60.44 13.42,60.44 13.88,60.9 13.88,61.17 v2(13.62,61.43)
TBT_I2C_B_N_R: length 5.6
  BOTTOM w0.127: JUSBC1.B7 6.38,60.93 7.21,60.93 v4(7.37,60.77) 7.51,60.63 10.02,60.63 10.19,60.79 D90.1 10.38,60.61 10.61,60.61 10.92,60.92 ML7.3
TBT_I2C_B_P: length 10.9
  TOP w0.076: U722.K7 21.26,61.72 20.87,61.72 20.75,61.6 20.11,61.6 18.92,60.41 18.28,60.41 18.24,60.46 18.22,60.46
  TOP w0.127: v2(14.22,61.43) 14.22,60.83 v4(14.42,60.62) 14.59,60.46 18.22,60.46
  BOTTOM w0.127: ML7.1 13.01,60.19 13.52,60.19 14.13,60.8 14.13,61.34 v2(14.22,61.43)
TBT_I2C_B_P_R: length 5.6
  BOTTOM w0.127: JUSBC1.B6 6.41,60.68 7.1,60.68 7.41,60.37 9.98,60.37 D91.1 10.39,60.35 10.68,60.35 10.95,60.07 ML7.2
TBT_I2C_CLK: length 67.9
  TOP w0.076: UT1.U2 45.03,55.68 45.03,55.3 44.77,55.04
  TOP w0.127: U722.D2 24.54,63.95 24.54,63.2 v2(24.49,63.15) ; RT36.2 44.52,53.68 v2(44.52,54.01) 44.52,54.34 44.77,54.59 44.77,55.04
  IN1 w0.081: v2(44.52,54.01) 44.39,54.14 44.39,54.3 44.77,54.68 44.77,55.14 44.32,55.59 43.19,55.59 42.77,55.17 42.77,53.33 40.91,51.47 38.41,51.47 36.23,49.3 34.42,49.3 31.73,46.61 31.73,42.64 27.06,37.96 24.48,37.96 23.84,38.6 23.84,45.74 26.18,48.08 26.18,49.63 26.68,50.13 26.68,53.02 24.84,54.85 24.84,56.06 23.89,57.01 23.89,58.36 24.16,58.63 24.16,59.19 23.2,60.15 23.2,61.25 23,61.46 23,62.81 22.74,63.06 22.74,63.63 23.09,63.98 24.41,63.98 24.48,63.97 24.48,63.97 24.56,63.88 v2(24.49,63.15)
TBT_I2C_DATA: length 68.4
  TOP w0.076: U722.D1 24.51,64.47 24.51,64.83 v2(24.66,64.98)
  TOP w0.127: UT1.U1 44.68,55.33 44.68,55.33 44.55,55.21 44.55,54.68 44.3,54.43 44.3,54.43 v2(43.9,54.03) 43.9,53.7 RT35.2
  IN1 w0.081: v2(24.66,64.98) 24.59,64.25 24.5,64.18 24.49,64.18 24.42,64.19 23,64.19 22.53,63.72 22.53,62.98 22.79,62.72 22.79,61.37 22.99,61.17 22.99,60.07 23.95,59.11 23.95,58.72 23.68,58.44 23.68,56.92 24.63,55.97 24.63,54.77 26.47,52.93 26.47,50.22 25.97,49.72 25.97,48.16 23.63,45.83 23.63,38.51 24.39,37.76 27.15,37.76 31.94,42.55 31.94,46.52 34.51,49.09 36.32,49.09 38.49,51.26 40.99,51.26 42.97,53.25 42.97,55.08 43.27,55.38 44.24,55.38 44.56,55.05 44.56,54.77 44.18,54.39 44.18,54.23 43.98,54.03 v2(43.9,54.03)
  BOTTOM w0.127: v2(24.66,64.98) 24.47,65.17 v1(24.04,65.17)
TBT_I2C_INT#: length 38.1
  TOP w0.127: v2(45.16,50.35) 45.16,50.86 RT47.2 ; v2(25.1,65.44) 25.1,64.88 25.07,64.85 25.07,64.83 25.01,64.77 U722.C1 ; UT1.J4 41.18,56.62 v2(40.87,56.31)
  IN3 w0.089: v2(40.87,56.31) 40.68,56.5 37.81,56.5 36.41,57.89 36.41,58.44 34.79,60.06 30.45,60.06 29.29,58.9 26.55,58.9 26.15,59.29 26.15,60.51 25.37,61.29 24.87,61.29 23.54,62.61 23.54,64.6 24.38,65.44 v2(25.1,65.44)
  BOTTOM w0.127: v2(25.1,65.44) 25.2,65.34 25.55,65.34 v1(25.67,65.46) ; v2(40.87,56.31) 39.9,55.34 39.9,54.01 40.62,53.29 41.59,53.29 42.55,52.33 42.55,52.27 43.71,51.1 44.54,51.1 45.16,50.48 v2(45.16,50.35)
TBT_JTAG_TCK: length 48.1
  TOP w0.127: RT7.2 49.12,73.77 49.41,74.06 49.41,75.27 ; 49.41,75.27 JAR1.3 ; 49.41,75.27 49.41,75.87 49.25,76.04 48.83,76.04 48.6,76.27 47.78,76.27 47.35,75.84 v1(47.35,74.85) 47.35,72.24 v2(47.5,72.09) ; v2(44.12,56.31) 44.13,56.31 44.44,56.62 UT1.T4
  IN4 w0.081: v2(47.5,72.09) 47.76,71.83 50.16,71.83 51.27,72.94 52.4,72.94 52.68,72.67 52.68,72.01 52.54,71.87 52.27,71.87 51.86,71.46 51.86,70.73 53.25,69.34 53.25,66.79 53.99,66.06 53.99,64.33 53.58,63.93 52.71,63.93 52.08,63.3 52.08,61.14 53.58,59.63 53.58,55.39 51.63,53.44 49.82,53.44 49.44,53.06 48.93,53.06 48.46,52.59 47.73,52.59 47.14,53.17 47.14,53.49 44.32,56.31 v2(44.12,56.31)
TBT_JTAG_TDI: length 35.1
  TOP w0.127: UT1.Y4 v2(46.07,56.94) ; JAR1.1 51.41,74.08 51.03,73.69 RT9.2 51.22,73.28 51.46,73.03 v2(51.46,72.25)
  IN4 w0.081: v2(46.07,56.94) 46.07,56.92 46.08,56.92 46.08,56.35 46.14,56.28 46.14,55.39 47.51,54.02 48.61,54.02 49.52,54.93 51.02,54.93 51.45,55.36 51.45,64.16 51.15,64.46 50.75,64.46 50.56,64.27 50.27,64.27 49.87,64.66 49.87,66.75 49.3,67.32 49.3,68.84 47.8,70.33 47.8,71.24 48.19,71.63 50.84,71.63 v2(51.46,72.25)
  BOTTOM w0.127: v2(51.46,72.25) v1(51.46,73.13)
TBT_JTAG_TDO: length 32.6
  TOP w0.127: v2(48.35,71.19) 47.92,71.62 47.92,73.08 48.24,73.4 RT6.2 48.49,74.02 48.41,74.1 JAR1.4 ; UT1.W4 v2(45.43,56.94)
  IN4 w0.081: v2(48.35,71.19) 48.34,71.19 48.34,70.08 49.48,68.94 50.55,68.94 51.5,67.99 51.5,66.44 51.93,66.01 51.93,65.33 51.66,65.05 51.66,54.72 50.8,53.86 49.64,53.86 49.32,53.54 48.64,53.54 48.37,53.81 47.42,53.81 45.49,55.74 45.49,56.88 45.43,56.94 v2(45.43,56.94)
TBT_JTAG_TMS: length 39.9
  TOP w0.127: v2(52.27,72.42) 52.27,72.71 v1(51.89,73.09) 51.89,73.55 51.92,73.58 51.92,75.97 51.56,76.32 51.14,76.32 50.86,76.04 50.65,76.04 50.41,75.8 JAR1.2 50.41,74.3 50.27,74.16 RT8.2 ; UT1.V4 44.79,56.93 v2(44.78,56.93)
  IN4 w0.081: v2(52.27,72.42) 52.2,72.42 51.35,71.57 51.35,69.4 52.35,68.4 52.35,67.4 53.78,65.97 53.78,64.42 53.49,64.13 52.62,64.13 51.87,63.38 51.87,61.05 52.58,60.34 52.58,59.83 52.43,59.67 52.43,58.91 51.87,58.35 51.87,54.63 50.89,53.65 49.73,53.65 49.34,53.27 48.84,53.27 48.37,52.8 47.81,52.8 47.35,53.26 47.35,53.59 44.78,56.16 v2(44.78,56.93)
TBT_LDO_BMC: length 2.1
  TOP w0.076: 24.08,65.36 24.08,64.54 U722.E1
  TOP w0.127: 24.08,65.36 24.65,65.93 CT144.1
TBT_LSRX: length 28.2
  TOP w0.127: RT45.2 v2(35.59,56.98) 36.21,56.98 36.36,56.84 UT1.A4 ; v2(17.61,63.17) 17.19,63.17 R1464.1
  IN1 w0.081: v2(17.61,63.17) 17.61,63.17 19.39,63.17 v2(19.46,63.23)
  IN3 w0.089: v2(19.46,63.23) 21.34,61.35 23.89,61.35 24.61,60.63 24.61,59.91 26.97,57.54 29.09,57.54 29.36,57.28 32.33,57.28 33.3,56.31 34.14,56.31 34.87,57.04 35.52,57.04 v2(35.59,56.98)
  BOTTOM w0.127: R1461.1 20.98,62.26 20.68,61.96 20.14,61.96 19.97,62.13 19.97,62.72 v2(19.46,63.23) ; v2(17.61,63.17) v1(18.33,63.17)
TBT_LSRX_R: length 1.5
  TOP w0.076: v2(21.92,63.18) 21.71,62.97 21.51,62.97 U722.K4
  BOTTOM w0.127: v2(21.92,63.18) 21.71,62.97 R1461.2
TBT_LSTX: length 33
  TOP w0.127: R1463.1 v2(16.45,64.5) ; UT1.A5 37.44,57.3 36.67,57.3 36.4,57.57 v2(35.59,57.57) 35.54,57.62 RT44.2 ; R1459.1 16.43,61.19 v2(16.43,61.6)
  IN3 w0.089: v2(35.59,57.57) 35.09,57.57 34.05,56.52 33.39,56.52 32.42,57.5 29.45,57.5 29.18,57.76 27.06,57.76 25.72,59.1 25.72,60.33 25.19,60.86 24.69,60.86 22.35,63.19 22.35,64.07 20.52,65.91 18.58,65.91 17.17,64.5 v2(16.45,64.5) 16.43,64.49 v2(16.43,61.6)
  BOTTOM w0.127: v3(16.05,62.49) 16.43,62.11 v2(16.43,61.6)
TBT_LSTX_R: length 5.4
  TOP w0.076: v2(20.04,63.24) 20.04,63.2 20.11,63.13 20.47,63.13 20.47,63.13 20.78,63.13 20.94,62.97 U722.L4
  TOP w0.127: v2(17.03,61.6) 17.03,61.18 R1459.2
  IN1 w0.081: v2(17.03,61.6) 18.12,62.69 19.5,62.69 v2(20.04,63.24)
TBT_PCIE_WAKE#: length 43.3
  TOP w0.076: 45.61,54.4 45.77,54.56 45.77,55.18 45.72,55.23 45.72,55.45 UT1.W1
  TOP w0.127: RT22.2 45.57,53.9 v2(45.47,54) 45.47,54.26 45.61,54.4
  IN2 w0.089: v2(45.47,54) 45.46,54 45.46,54 45.13,54 44.58,53.45 43.47,53.45 42.48,52.46 42.48,52.43 41.32,51.27 41.32,50.18 40.28,49.15 40.28,46.42 39.62,45.76 39.62,36.67 39.08,36.13 39.08,34.82 38.75,34.49 38.75,31.85 38.96,31.63 v2(38.96,30.97)
  IN3 w0.089: v2(47.37,35.26) 47.97,34.66 47.97,32.17 47.44,31.63 46.53,31.63 46.22,31.32 44.36,31.32 44.23,31.45 39.82,31.45 39.35,30.97 v2(38.96,30.97)
  BOTTOM w0.127: v2(47.37,35.26) 46.94,35.26 RE120.1
TBT_PD_SBU1: length 3.9
  TOP w0.076: U722.K8 21.36,60.82 21.36,60.82 21.27,60.73 20.82,60.73
  TOP w0.127: R1457.1 18.64,58.8 19.17,59.32 19.35,59.32 20.76,60.73 20.82,60.73
TBT_PD_SBU2: length 3.4
  TOP w0.127: U722.L8 20.66,60.97 19.21,59.53 18.98,59.53 18.67,59.22 R1458.1
TBT_PERST_N: length 5.7
  TOP w0.127: UT1.L4 41.56,56.9 41.56,56.9 v2(41.53,56.94) ; R104.2 41.89,53.72 v2(41.51,54.09)
  BOTTOM w0.127: v2(41.53,56.94) 41.57,56.9 41.57,56.02 41.14,55.6 40.88,55.6 40.41,55.13 40.41,54.4 40.72,54.09 v2(41.51,54.09)
TBT_PWR_EN: length 25.5
  TOP w0.127: v2(155.07,58.68) 155.7,59.32 v3(155.7,59.45)
  IN3 w0.089: v2(155.07,58.68) 153.37,58.68 152.75,59.31 150.14,59.31 149.92,59.08 145.57,59.08 144.03,57.54 144.03,56.94 143.02,55.93 143.02,52.88 144.02,51.88 147.58,51.88 v2(148.13,52.44)
  BOTTOM w0.127: RH556.1 155.4,59.01 v2(155.07,58.68) ; UCPU1.AW7 148.37,52.2 v2(148.13,52.44)
TBT_RBIAS: length 14.5
  TOP w0.127: v1(42.68,50.45) 42.78,50.55 RT10.1 43.66,50.26 v2(44.22,49.7) ; v2(40.87,57.59) 40.87,57.59 UT1.H6
  BOTTOM w0.127: v2(40.87,57.59) 40.69,57.41 40.69,56.79 39.65,55.75 39.65,53.9 40.51,53.03 41.49,53.03 42.28,52.24 42.28,52.03 43.46,50.85 44.39,50.85 44.74,50.5 44.74,50.08 44.36,49.7 v2(44.22,49.7)
TBT_RESET_N: length 16.2
  TOP w0.127: RT120.1 28.66,46.21 27.7,47.17 27.14,47.17 v2(27.04,47.08) ; U722.F11 23.5,59.46 v2(23.5,58.86)
  IN3 w0.089: v2(27.04,47.08) 27,47.08 25.95,48.13 25.95,54.51 23.5,56.96 v2(23.5,58.86)
TBT_RESET_N_R: length 25.9
  TOP w0.127: RT120.2 29.59,46.8 RT121.2 v1(29.62,47.89) 30.36,48.64 32.05,48.64 32.5,48.19 RT51.2 32.77,48.5 32.9,48.64 v2(35.21,48.64) ; UT1.F4 39.9,56.62 39.88,56.62 39.57,56.92 v2(39.58,56.94)
  IN1 w0.081: v2(35.21,48.64) 35.59,48.25 37.55,48.25 39,49.7 40.82,49.7 41.33,50.21 v2(41.78,50.21)
  BOTTOM w0.127: v2(41.78,50.21) 41.14,50.21 39.99,51.35 39.99,52.1 40.13,52.24 40.13,52.69 39.36,53.46 38.55,53.46 38.34,53.67 38.34,55.69 v2(39.58,56.94)
TBT_ROM_CLK: length 30
  TOP w0.076: v2(48.5,55.82) 48.5,55.92 47.83,56.6 47.33,56.6 47.1,56.83 UT1.AB4
  TOP w0.127: UT5.6 44.1,41.7 44.1,42.26 45.77,43.93 46.94,43.93 47.34,43.52 v2(47.88,43.52) v3(48.75,43.52)
  BOTTOM w0.127: v2(48.5,55.82) 47.67,55.82 46.99,55.14 46.99,53.67 48.44,52.22 48.44,50.94 50.82,48.55 50.82,46.69 51.18,46.34 51.18,45.34 51.88,44.64 51.88,42.78 51.49,42.39 50.87,42.39 50.35,42.91 48.49,42.91 v2(47.88,43.52)
