# Allegro board LAD841PR10-0621.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3VALW on TOP (solid shape): 200.64,41.31 200.64,39.66 200.23,39.25 199.5,39.25 198.45,39.25 197.71,39.25 197.66,39.3 197.66,39.73 197.94,40.01 197.95,40.02 198.07,40.1 198.15,40.22 198.16,40.23 198.2,40.27 198.2,41.12 198.31,41.23 198.98,41.23 199.14,41.39 200.56,41.39
+3VALW on TOP (solid shape): 178.98,34.46 178.98,34.07 178.98,34.07 178.98,33.17 178.92,33.11 178.28,33.11 178.16,32.98 176.89,32.98 176.63,33.23 176.63,34.51 176.67,34.59 176.76,34.61 176.97,34.63 177.13,34.76 178.68,34.76
+3VALW on TOP (solid shape): 34.09,44.78 34.27,44.74 34.45,44.78 34.46,44.79 34.59,44.79 34.84,44.55 34.89,44.55 35.03,44.41 35.03,44.15 34.65,43.77 34.65,42.63 34.52,42.5 33.88,42.5 33.76,42.63 33.76,43.27 33.88,43.39 33.88,43.52 33.99,43.77 33.88,44.02 33.88,44.66 34.01,44.79 34.07,44.79
+3VALW on TOP (solid shape): 178.49,48.06 178.49,46.87 178.6,46.76 178.72,46.76 178.74,46.75 179,46.7 179.23,46.86 179.29,46.92 179.29,48.08 179.35,48.13 180.1,48.13 180.15,48.08 180.15,46.73 180.01,46.59 179.96,46.55 179.92,46.49 179.66,46.23 177.74,46.23 177.03,45.52 176.38,45.52 176.33,45.58 176.33,46.05 176.38,46.1 176.86,46.1 177.23,46.47 177.23,46.72 177.91,47.39 177.91,48.04 178.01,48.14 178.41,48.14
+3VALW on TOP (solid shape): 40.52,41.87 40.54,41.85 40.58,41.81 40.63,41.78 40.66,41.76 40.74,41.68 40.74,40.08 40.24,39.58 37.62,39.58 37.54,39.66 37.54,40.18 37.56,40.19 37.6,40.23 37.64,40.27 37.65,40.3 37.69,40.34 37.69,40.57 38.46,40.57 38.46,40.52 38.46,40.47 38.48,40.42 38.5,40.37 38.53,40.32 38.57,40.29 38.61,40.25 38.66,40.23 38.71,40.21 38.76,40.19 38.81,40.19 38.86,40.19 38.92,40.21 38.97,40.23 39.01,40.25 39.05,40.29 39.09,40.32 39.12,40.37 39.14,40.42 39.16,40.47 39.17,40.52 39.17,40.57 39.16,40.63 39.14,40.68 39.12,40.73 39.09,40.77 39.05,40.81 39.01,40.84 38.97,40.87 38.92,40.89 38.86,40.9 38.81,40.9 38.76,40.9 38.71,40.89 38.66,40.87 38.61,40.84 38.57,40.81 38.53,40.77 38.5,40.73 38.48,40.68 38.46,40.63 38.46,40.57 37.69,40.57 37.69,40.98 37.62,41.06 37.62,41.79 37.69,41.87
+3VALW on TOP (solid shape): 50.27,51.65 50.27,50.63 50.52,50.38 50.82,50.38 50.85,50.35 50.93,50.35 51.92,49.36 51.92,47.39 51.73,47.2 50.78,47.2 50.65,47.33 50.65,47.71 50.39,47.96 50.39,48.73 50.19,48.93 50.9,48.93 50.9,48.88 50.91,48.82 50.93,48.77 50.95,48.73 50.98,48.68 51.02,48.64 51.06,48.61 51.1,48.58 51.15,48.56 51.2,48.55 51.26,48.55 51.31,48.55 51.36,48.56 51.41,48.58 51.46,48.61 51.5,48.64 51.54,48.68 51.57,48.73 51.59,48.77 51.61,48.82 51.61,48.88 51.61,48.93 51.61,48.98 51.59,49.03 51.57,49.08 51.54,49.13 51.5,49.17 51.46,49.2 51.41,49.23 51.36,49.24 51.31,49.26 51.26,49.26 51.2,49.26 51.15,49.24 51.1,49.23 51.06,49.2 51.02,49.17 50.98,49.13 50.95,49.08 50.93,49.03 50.91,48.98 50.9,48.93 50.19,48.93 50.01,49.11 49.58,49.11 49.56,49.13 49.51,49.16 49.46,49.18 49.41,49.2 49.35,49.21 49.3,49.21 49.24,49.2 49.19,49.18 49.14,49.16 49.1,49.13 49.08,49.11 48.62,49.11 48.49,49.23 48.49,51.65 48.62,51.77 50.14,51.77
+3VALW on TOP (solid shape): 61.32,79.97 61.32,79.08 60.96,78.72 60.88,78.72 60.88,78.65 60.81,78.57 60.81,78.06 60.68,77.94 60.17,77.94 60.02,77.79 59.95,77.76 59.88,77.78 59.35,77.7 59.51,77.19 59.54,77.17 59.54,76.54 59.28,76.29 58.14,76.29 58.01,76.16 58.01,75.52 57.89,75.4 57,75.4 56.74,75.65 56.74,77.68 57,77.94 59.03,77.94 59.15,78.05 59.16,78.06 59.27,78.13 59.34,78.24 59.34,78.25 59.41,78.32 59.41,79.3 59.44,79.33 59.46,79.35 59.5,79.37 59.54,79.35 60.18,79.43 59.7,79.86 59.67,79.85 59.6,79.91 59.77,80.07 61.22,80.07
+3VALW on BOTTOM (solid shape): 200.89,67.14 200.89,65.45 200.55,65.11 200.55,63.99 200.32,63.99 200.32,65.3 199.87,65.74 199.87,67.14 200,67.27 200.76,67.27
+3VALW on BOTTOM (solid shape): 75.19,17 75.95,17 75.95,17.55 76.38,17.55 76.38,17.02 77.16,17.02 77.16,17.55 79.79,17.55 79.95,17.4 79.95,17.14 79.95,17.14 79.95,16.43 79.71,16.19 73.17,16.19 73.17,16.19 72.77,16.19 72.62,16.34 72.62,17.39 72.78,17.55 75.19,17.55
+3VALW on BOTTOM (solid shape): 28.55,21.68 28.55,20.53 29.19,19.9 29.19,19.77 29.06,19.64 28.46,19.64 26.92,19.64 26.77,19.8 26.77,20.79 27.31,21.32 27.32,21.32 27.53,21.43 27.64,21.64 27.64,21.65 27.79,21.8 28.42,21.8
+3VALW on IN1 (solid shape): outline of 197 points within 41.38,76.29 61.44,79.94
+3VALW on IN2 (solid shape): outline of 199 points within 171.3,33.74 177.9,58.27
+3VALW on IN2 (solid shape): outline of 757 points within 25.24,44.03 35.28,70.29
+3VALW on IN3 (solid shape): outline of 496 points within 27,39.46 41,53.3
+3VALW on IN4 (solid shape): 27.29,70.89 27.29,70.2 25.76,68.67 25.25,68.67 25.12,68.79 25.12,69.94 26.36,71.17 27.01,71.17
+3VALW on IN4 (solid shape): outline of 93 points within 38.2,75.93 42.52,77.79
+3VALW on VCC: 108.09,12.57 108.03,12.68 107.95,12.79 107.95,14.97 104.61,14.97 104.61,13.47 96.99,13.47 96.76,13.51 96.55,13.62 95.22,14.62 94.29,15.1 93.26,15.27 72.7,15.27 72.17,15.19 71.7,14.96 66.65,20 66.65,20.89 51.64,35.9 47.83,35.9 44.78,38.95 40.72,38.95 39.85,39.81 39.85,46.21 42.12,48.47 51.69,48.47 52.57,47.58 68.96,47.58 69.72,46.82 88.49,46.82 88.49,44.3 89.15,43.65 96.62,43.65 96.62,36.17 98.02,34.78 98.02,33.89 99.16,32.75 99.16,24.49 103.25,20.41 158.07,20.41 160.23,22.56 170.26,22.56 171.55,23.86 171.55,34.65 175.09,38.19 198.33,38.19 201.63,41.49 204.93,41.49 204.93,40.92 206.72,30.76 211.87,21.81 211.87,19.41 212.68,17.68 214.52,17.18 215.93,16.79 216.54,15.47 216.54,13.47 132.59,13.47 131.7,13.23 131.05,12.57 127.13,12.57 126.48,13.23 125.59,13.47 115.47,13.47 115.47,14.97 112.23,14.97 112.23,12.89 112.11,12.74 112,12.57
+3VALW_5085 on TOP (solid shape): 192.76,61.03 192.76,59.88 192.75,59.85 192.73,59.8 192.73,59.75 192.73,59.7 192.73,59.65 192.75,59.6 192.76,59.57 192.76,58.52 192.75,58.49 192.63,58.38 192,58.38 192,58.89 191.36,59.53 191.69,59.53 191.69,59.47 191.7,59.42 191.71,59.37 191.74,59.32 191.77,59.28 191.8,59.24 191.84,59.21 191.89,59.18 191.94,59.16 191.99,59.15 192.04,59.14 192.1,59.15 192.15,59.16 192.2,59.18 192.24,59.21 192.29,59.24 192.32,59.28 192.35,59.32 192.38,59.37 192.39,59.42 192.4,59.47 192.4,59.53 192.39,59.58 192.38,59.63 192.35,59.68 192.32,59.72 192.29,59.76 192.24,59.79 192.2,59.82 192.15,59.84 192.1,59.85 192.04,59.86 191.99,59.85 191.94,59.84 191.89,59.82 191.84,59.79 191.8,59.76 191.77,59.72 191.74,59.68 191.71,59.63 191.7,59.58 191.69,59.53 191.36,59.53 191.23,59.66 191.23,61.43 191.33,61.53 192.26,61.53
+3VALW_5085 on BOTTOM (solid shape): 171.82,64.44 171.82,63.37 171.78,63.33 170.21,63.33 170.03,63.51 170.03,64.47 170.16,64.6 171.66,64.6
+3VALW_5085 on IN2 (solid shape): 171.46,64.32 174.69,64.32 174.77,64.4 175.04,64.4 175.38,64.06 175.38,63.85 175.05,63.53 175.02,63.51 174.98,63.53 174.51,63.56 174.42,63.1 174.42,63 174.33,62.95 171.59,62.95 171.37,63.02 171.16,62.95 170.03,62.95 168.89,64.09 168.89,64.43 171.35,64.43
+3VALW_5085 on IN2 (solid shape): 178.79,71.84 179.83,71.84 180.72,70.95 184,70.95 184.25,70.7 184.25,69.55 184,69.3 182.82,69.3 182.75,69.33 182.72,69.41 182.72,69.42 182.68,69.6 182.54,69.74 182.52,69.8 182.54,69.86 182.54,69.87 182.59,69.89 182.63,69.86 183.31,69.96 182.7,70.25 182.61,70.22 182.54,70.27 181.99,70.31 182.04,69.77 182.08,69.72 182.08,69.65 182.02,69.54 182.01,69.42 182.01,69.41 181.98,69.33 181.91,69.3 181.76,69.3 181.69,69.33 181.66,69.41 181.66,69.42 181.45,69.76 181.06,69.69 181.01,69.68 180.96,69.69 180.91,69.73 180.89,69.77 180.9,69.8 180.85,70.28 180.36,70.26 180.25,70.23 180.19,70.33 180.19,70.44 179.81,70.82 178.41,70.82 177.6,71.64 177.6,72.04 177.9,72.35 178.28,72.35
+3VALWP on TOP (solid shape): 82.65,23.2 82.65,18.63 82.4,18.37 78.84,18.37 78.59,18.63 78.59,23.33 79.1,23.83 82.02,23.83
+3VALWP on BOTTOM (solid shape): 82.65,23.2 82.65,17.99 82.37,17.71 74.51,17.71 74.4,17.81 74.4,19.01 74.65,19.26 77.97,19.26 78.59,19.88 78.59,23.2 79.1,23.71 82.14,23.71
+3VLP on BOTTOM (solid shape): 88.75,20.35 88.75,19.77 88.55,19.57 88.09,19.54 88.05,19.08 87.87,18.9 87.85,18.9 87.53,18.8 87.43,18.49 87.44,18.46 87.22,18.25 87.22,16.39 87.07,16.24 85.95,16.24 85.83,16.37 85.83,17.87 87.35,19.39 87.35,20.28 87.53,20.46 88.64,20.46
+3VS on TOP (solid shape): 40.49,47.98 40.49,47.61 40.44,47.43 40.49,47.25 40.49,45.68 40.62,45.55 41.25,45.55 41.3,45.5 41.3,44.46 41.12,44.28 40.87,44.28 40.58,44.57 40.53,44.57 40.3,44.8 40.3,45.04 38.9,45.04 38.9,45.71 38.53,46.07 38.53,47.63 39.15,48.25 40.22,48.25
+3VS on IN3 (solid shape): outline of 865 points within 184.25,37.3 193.14,44.6
+3VS on IN4 (solid shape): outline of 490 points within 23.51,42.12 39.71,47.92
+3VS_AUDIO on TOP (solid shape): 34.9,38.31 34.9,36.99 34.7,36.79 33.83,36.79 33.4,36.36 32.92,36.36 32.36,36.92 32.36,37.55 32.74,37.93 33.5,37.93 33.63,38.06 33.63,38.31 33.76,38.44 34.77,38.44
+3VS_CR on TOP (solid shape): 180.03,16.45 180.07,16.45 180.19,16.34 180.19,14.94 179.93,14.69 177.39,14.69 174.82,17.27 174.82,20.32 174.93,20.43 175.18,20.43 175.32,20.46 175.44,20.53 175.96,20.53
+3VS_CR on BOTTOM (solid shape): outline of 100 points within 192.13,15.07 197.84,27.64
+3VS_CR on IN3 (solid shape): outline of 552 points within 178.79,13.55 198.98,20.28
+3VS_NGFF on TOP (solid shape): 49.38,47.33 50.01,47.33 50.14,47.2 50.14,46.31 50.01,46.19 46.97,46.19 46.84,46.31 46.84,47.08 47.64,47.88 47.99,47.88 48.11,47.99 48.17,48.04 48.21,48.09 48.62,48.09
+3VS_NGFF on TOP (solid shape): 32.45,47.88 33.26,47.88 33.31,47.87 33.35,47.87 34.03,47.87 34.04,47.87 34.24,47.84 34.42,47.92 34.49,47.95 34.56,47.92 34.93,47.55 34.93,47.54 35.01,47.42 35.14,47.34 35.27,47.32 35.36,47.33 36.42,47.33 36.55,47.2 36.55,46.48 36.42,46.35 34.96,46.35 34.8,46.19 33.63,46.19 33.38,46.44 33.31,46.44 33.3,46.45 33.12,46.49 32.93,46.44 30.58,46.44 30.47,46.55 30.47,47.47 30.69,47.69 30.71,47.7 30.86,47.79 30.95,47.94 30.95,47.95 31.22,48.22 32.12,48.22
+3VS_NGFF on BOTTOM (solid shape): 48.49,48.34 48.62,48.32 48.74,48.34 48.75,48.35 49.12,48.35 49.76,47.71 49.76,45.75 49.56,45.55 48.92,45.55 48.84,45.63 48.84,47.1 48.74,47.2 48.61,47.2 48.61,47.21 48.5,47.23 48.39,47.21 48.38,47.2 48.11,47.2 48.11,47.21 48,47.23 47.89,47.21 47.88,47.2 47.73,47.2 47.47,47.46 47.47,48.09 47.73,48.35 48.48,48.35
+3VS_NGFF on BOTTOM (solid shape): 33.74,48.37 33.81,48.33 33.84,48.25 34.14,47.84 34.54,48.16 34.61,48.25 34.71,48.23 34.77,48.17 34.77,47.2 34.52,46.95 33.63,46.95 33.25,47.33 32.49,47.33 32.16,47 32.16,45.63 32.08,45.55 31.42,45.55 31.09,45.88 31.09,48.12 31.34,48.37
+3VS_NGFF on IN3 (solid shape): outline of 465 points within 33.63,43.27 48.62,48.98
+3VS_TP on TOP (solid shape): 168.46,17.41 169.34,17.41 169.39,17.36 169.39,16.85 169.27,16.72 168.83,16.72 167.62,16.72 167.49,16.85 167.49,17.83 167.65,17.99 167.88,17.99
+3VS_TP on IN1 (solid shape): outline of 125 points within 186.92,14.18 190.98,19.9
+3VS_TPM on TOP (solid shape): 182.09,46.14 182.09,40.6 182.68,40.01 183.56,40.01 184.22,40.67 184.56,40.67 184.63,40.6 184.63,40.36 184.52,40.18 184.53,39.97 184.54,39.94 183.93,39.33 182.41,39.33 180.97,40.77 180.97,41.16 180.95,41.18 180.95,43.57 181.1,43.72 181.1,45.39 180.95,45.54 180.95,46.14 181,46.19 182.04,46.19
+3VS_TPM on IN1 (solid shape): outline of 288 points within 183.62,39.33 191.11,45.93
+5V_USB_P2 on TOP (solid shape): 18.97,51.24 18.97,50.99 19.23,50.73 20.7,50.73 20.78,50.66 20.78,49.16 20.65,49.03 17.93,49.03 17.76,49.21 17.76,51.27 17.88,51.39 18.82,51.39
+5V_USB_P2 on BOTTOM (solid shape): 20.55,51.39 20.55,50 20.8,49.74 20.8,46.82 20.68,46.69 16.87,46.69 15.47,48.09 13.95,48.09 13.69,48.35 13.69,49.87 14.2,50.38 16.99,50.38 18.26,51.65 20.3,51.65
+5VALW on TOP (solid shape): 194.54,17.48 194.54,16.21 194.41,16.09 193.14,16.09 193.02,16.21 193.02,16.85 193.4,17.23 193.4,17.87 193.52,17.99 194.03,17.99
+5VALW on TOP (solid shape): 52.87,18.84 52.91,18.8 53.9,18.8 54.23,18.47 54.23,17.64 54.08,17.48 51.69,17.48 51.54,17.64 51.54,19.39 51.61,19.47 52.25,19.47
+5VALW on TOP (solid shape): 28.87,51.34 28.87,49.74 28.74,49.62 23.6,49.62 23.47,49.74 23.47,50.69 23.6,50.82 25.12,50.82 25.54,51.24 27.51,51.24 27.76,51.49 28.72,51.49
+5VALW on TOP (solid shape): 53.52,22.38 53.52,22.1 53.34,21.84 53.45,21.54 52.76,20.85 51.6,20.85 51.54,20.91 51.54,21.37 51.54,21.37 51.54,21.48 50.9,22.11 50.9,22.72 50.94,22.75 51.12,22.75 51.13,22.75 51.41,22.74 51.61,22.94 51.62,22.95 52.03,23.37 52.53,23.37
+5VALW on TOP (solid shape): 24.6,59.63 24.6,59.26 24.59,59.25 24.58,59.13 24.63,59.03 24.85,58.81 24.88,58.74 24.86,58.67 25.17,58.08 25.31,58.73 25.31,58.89 24.93,59.27 24.93,59.61 24.97,59.65 25.1,59.65 25.19,59.56 26.04,59.56 26.09,59.5 26.09,59.36 26.13,59.32 26.15,59.27 26.18,59.23 26.85,58.57 27.22,58.57 27.41,58.38 27.41,58.35 27.43,58.35 27.53,58.25 28.82,58.25 29.18,57.89 29.18,57.87 29.2,57.79 29.23,57.72 29.29,57.66 29.36,57.62 29.41,57.6 29.46,57.59 29.5,57.58 29.5,57.25 29.49,57.23 29.49,56.72 29.48,56.71 29.46,56.58 29.5,56.46 29.5,56.45 29.5,55.77 29.82,55.46 29.82,54.44 28.86,53.48 28.43,53.48 27.41,54.5 27.41,55.08 27.52,55.19 27.78,55.19 28.04,55.46 28.04,55.8 27.89,55.95 27.89,56.96 27.61,57.24 24.36,57.24 24.23,57.36 24.23,58.4 24.27,58.43 24.27,59.59 24.32,59.65 24.58,59.65
+5VALW on BOTTOM (solid shape): 61.41,49.44 61.41,48.9 61.35,48.71 61.41,48.53 61.41,47.34 61.24,47.18 60.05,47.18 60.05,47.71 59.23,47.71 59.23,47.18 58.83,47.18 58.83,47.71 58.01,47.71 58.01,47.2 57.3,47.2 56.38,48.12 56.38,49.6 56.48,49.7 61.14,49.7
+5VALW on BOTTOM (solid shape): 195.17,18.63 195.17,18.06 195.14,18.05 194.91,17.81 194.98,17.49 195,17.42 194.98,17.36 194.91,17.03 195.14,16.79 195.17,16.78 195.17,16.34 194.92,16.09 194.92,15.07 194.79,14.94 192,14.94 191.87,15.07 191.87,16.98 192,17.1 192,17.11 192.02,17.13 192.15,17.42 192,17.7 192,18.63 192.13,18.75 195.05,18.75
+5VALW on IN3 (solid shape): 53.34,22.54 53.34,19.91 53.3,19.83 53.22,19.81 52.78,19.46 53.22,19.11 53.3,19.09 53.34,19.01 53.34,18.78 52.81,18.25 51.79,18.25 51.54,18.5 51.54,22.41 51.79,22.67 53.21,22.67
+5VALW on IN3 (solid shape): outline of 398 points within 96.24,14.94 156.95,19.26
+5VALW on IN4 (solid shape): outline of 1511 points within 153.03,13.55 194.79,20.53
+5VALW on IN4 (solid shape): outline of 2739 points within 66.9,13.55 99.8,25.74
+5VALW on GND2: 153.39,13.65 153.39,15.35 157.43,19.39 176.4,19.39 177.54,18.25 193.29,18.25 194.54,17 194.54,14.67 193.42,13.55 153.5,13.55
+5VALW on VCC: outline of 95 points within 1.27,1.27 88.49,80.73 ; 3 cut-outs
+5VALWP on TOP (solid shape): 54.33,49.62 54.33,47.63 54.79,47.16 56.11,47.16 56.49,46.78 56.49,45.68 56.36,45.55 53.7,45.55 53.57,45.68 53.57,45.75 53.57,49.54 53.57,49.62 53.7,49.74 54.2,49.74
+5VALWP on BOTTOM (solid shape): 56.24,49.62 56.24,48.08 57.31,47.01 58.18,47.01 58.18,47.52 58.68,47.52 58.68,47.01 59.38,47.01 59.38,47.52 59.88,47.52 59.88,47.01 60.5,47.01 60.68,46.82 60.68,45.62 59.97,44.92 58.08,44.92 56.67,43.51 56.67,41.05 55.81,40.19 52.45,40.19 52.35,40.29 52.35,44.42 53.97,46.04 54.95,46.04 55.02,46.11 55.02,46.74 55.6,47.32 55.6,49.62 55.73,49.74 56.11,49.74
+5VS on TOP (solid shape): 47.12,18.92 47.12,16.62 46.97,16.47 45.31,16.47 44.81,16.98 44.81,17.36 45.82,18.37 45.82,18.77 46.01,18.96 47.08,18.96
+5VS_AUDIO on TOP (solid shape): 23.09,20.61 23.22,20.48 23.22,19.87 23.04,19.69 21.16,19.69 20.9,19.95 20.9,20.61 21.03,20.74 23.09,20.74
+5VS_AUDIO on TOP (solid shape): 47.45,23.2 47.45,21.04 47.35,20.94 46.41,20.94 46.28,21.07 46.28,21.4 46.13,21.55 46.06,21.55 46.05,21.55 45.95,21.57 45.84,21.56 45.81,21.56 45.57,21.8 45.57,22.95 45.85,23.23 47.42,23.23
+5VS_AUDIO on BOTTOM (solid shape): 23.72,21.8 23.72,20.28 23.6,20.15 21.69,20.15 21.44,20.41 21.44,20.86 21.48,20.87 21.74,21.22 21.48,21.56 21.44,21.57 21.44,21.8 21.57,21.93 23.6,21.93
+5VS_AUDIO on BOTTOM (solid shape): 34.65,27.14 34.65,25.87 35.28,25.23 35.28,23.83 34.9,23.45 32.36,23.45 31.98,23.83 28.8,23.83 28.68,23.96 28.68,24.52 28.68,24.6 28.8,24.72 29.41,24.72 29.41,24.65 30.23,24.65 30.23,24.72 30.33,24.72 30.43,24.83 33.38,24.83 33.38,24.77 33.38,24.72 33.4,24.67 33.42,24.62 33.45,24.58 33.49,24.54 33.53,24.5 33.58,24.48 33.63,24.46 33.68,24.45 33.73,24.44 33.78,24.45 33.84,24.46 33.89,24.48 33.93,24.5 33.97,24.54 34.01,24.58 34.04,24.62 34.06,24.67 34.08,24.72 34.09,24.77 34.09,24.83 34.08,24.88 34.06,24.93 34.04,24.98 34.01,25.02 33.97,25.06 33.93,25.09 33.89,25.12 33.84,25.14 33.78,25.15 33.73,25.16 33.68,25.15 33.63,25.14 33.58,25.12 33.53,25.09 33.49,25.06 33.45,25.02 33.42,24.98 33.4,24.93 33.38,24.88 33.38,24.83 30.43,24.83 30.58,24.98 32.23,24.98 33.25,25.99 33.25,26.76 33.12,26.88 31.73,26.88 31.6,27.01 31.6,27.52 32.36,28.28 33.5,28.28
+5VS_AUDIO on IN4 (solid shape): 33.41,25.23 33.51,25.17 33.49,25.06 33.47,24.56 33.97,24.53 34.08,24.55 34.14,24.46 34.14,23.66 33.93,23.45 32.99,23.45 31.83,22.29 31.81,22.29 31.67,22.27 31.55,22.2 31.49,22.18 31.42,22.2 30.9,22.15 31,21.63 31.04,21.56 31.02,21.47 29.9,20.36 29.8,20.34 29.73,20.42 29.12,20.64 29.34,20.04 29.43,19.97 29.41,19.86 29.31,19.77 27.49,19.77 27.4,19.82 27.39,19.91 27.06,20.41 26.74,19.91 26.73,19.82 26.64,19.77 21.82,19.77 21.57,20.02 21.57,20.91 21.74,21.16 21.66,21.45 21.65,21.48 21.66,21.52 21.82,21.68 24.08,21.68 24.16,21.63 24.18,21.55 24.17,21.37 24.25,21.21 24.28,21.15 24.25,21.08 24.51,20.48 24.78,21.07 24.75,21.14 24.78,21.21 24.87,21.37 24.86,21.55 24.88,21.63 24.96,21.68 26.9,21.68 26.91,21.63 27.26,21.34 27.61,21.63 27.62,21.68 28.42,21.68 31.98,25.23
+5VS_AUDIO on VCC: 34.32,20.53 31.6,23.25 31.6,26.73 31.34,26.99 31.34,28.55 31.58,28.79 32.13,28.79 32.87,28.05 32.87,26.78 35.3,24.34 37.46,24.34 38.6,23.2 46.48,23.2 46.71,22.97 46.71,20.89 46.35,20.53
+AVDD1 on BOTTOM (solid shape): 22.71,25.36 22.71,24.85 22.2,24.34 22.2,24.25 22.2,24.24 22.19,23.92 22.44,23.71 22.46,23.71 22.58,23.58 23.47,23.58 23.6,23.45 23.6,22.31 23.47,22.18 21.9,22.18 21.81,22.27 21.81,23.23 21.06,23.99 21.06,24.23 21.06,24.23 21.06,25.02 21.52,25.49 22.58,25.49
+AVDD1 on BOTTOM (solid shape): 23.48,33.6 24.02,33.6 24.16,33.46 24.16,32.58 24.1,32.39 24.16,32.21 24.16,31.33 23.9,31.07 23.79,31.07 23.78,31.11 23.44,31.35 23.11,31.11 23.09,31.07 21.95,31.07 21.82,31.2 21.82,32.47 22.07,32.72 22.07,33.49 22.2,33.61 23.47,33.61
+PVDD1 on TOP (solid shape): 27.16,27.02 27.16,25.49 26.11,24.43 25.87,24.43 25.78,24.51 25.78,24.55 25.75,24.55 25.75,24.72 26.95,25.92 26.95,27.02 27.01,27.07 27.11,27.07
+PVDD1 on BOTTOM (solid shape): 27.28,25.87 27.28,25.61 26.61,24.94 26.61,24.86 26.6,24.85 26.59,24.74 26.6,24.63 26.61,24.62 26.61,24.38 26.77,24.22 27.41,24.22 27.79,24.6 28.42,24.6 28.55,24.47 28.55,22.18 28.42,22.06 27.66,22.06 27.53,22.18 27.53,22.56 27.28,22.82 26.39,22.82 25.63,23.58 25.63,25.49 26.49,26.35 26.8,26.35
+PVDD2 on TOP (solid shape): 29.19,27.03 29.19,26.08 29.4,25.88 29.58,25.88 29.62,25.84 30.3,25.84 30.34,25.8 30.34,25.51 30.23,25.41 29.3,25.41 28.95,25.76 28.95,25.94 28.96,25.94 28.96,27.09 29.14,27.09
+PVDD2 on BOTTOM (solid shape): 31.55,26.7 32,26.7 32.11,26.6 32.11,26.09 32.08,26.07 32.03,26.06 31.97,26.04 30.48,26.04 30.33,25.89 30.33,25.54 30.2,25.41 29.41,25.41 29.41,25.41 27.97,25.41 27.74,25.64 27.74,26.63 27.88,26.78 29.41,26.78 29.59,26.96 31.29,26.96
+VBUS_DC_SS on BOTTOM (solid shape): 47.66,78.76 47.66,76.86 47.54,76.73 44.81,76.73 44.68,76.86 44.68,78.76 44.81,78.89 47.54,78.89
+VCC0V9_CIO on IN3 (solid shape): outline of 991 points within 42.98,53.65 49.21,60.54
+VCC0V9_DP on BOTTOM (solid shape): outline of 382 points within 44.55,53.68 50.14,61.93
+VCC0V9_DP on IN1 (solid shape): outline of 932 points within 40.99,55.83 45.11,62.92
+VCC0V9_PCIE on TOP (solid shape): 42.49,68.18 42.49,66.96 42.57,66.96 42.77,66.76 42.77,66.45 42.72,66.4 42.67,66.35 42.35,66.35 42.28,66.41 42.2,66.45 42.19,66.45 42.08,66.57 42.09,66.6 42.05,66.94 41.74,67.09 41.44,67.09 41.34,67.19 41.34,68.25 41.37,68.28 42.39,68.28
+VCC0V9_PCIE on IN1 (solid shape): outline of 351 points within 41.25,61.17 44.3,67.4
+VCC0V9_USB on BOTTOM (solid shape): outline of 365 points within 42.4,61.85 48.95,66.79
+VCC_CORE on TOP (solid shape): outline of 1940 points within 90.78,55.33 134.77,73.36
+VCC_CORE on BOTTOM (solid shape): outline of 108 points within 90.78,60.66 106.31,72.22
+VCC_CORE on BOTTOM (solid shape): outline of 541 points within 127.36,65.92 134.55,68.73
+VCC_CORE on BOTTOM (solid shape): outline of 661 points within 128.94,55.39 133.99,58.42
+VCC_CORE on IN1 (solid shape): outline of 5001 points within 91.29,55.97 134.47,66.89
+VCC_CORE on IN2 (solid shape): outline of 569 points within 127.48,56.98 134.21,67.4
+VCC_CORE on IN3 (solid shape): outline of 646 points within 127.48,56.98 134.98,67.4
+VCC_CORE on VCC: 130.38,56.85 128.6,58.63 127.23,58.63 127.23,62.29 126.57,62.95 118.06,62.95 117.81,63.2 116.92,63.2 116.16,63.97 97.11,63.97 93.81,60.66 89,60.66 89,69.58 93.55,74.13 104.24,74.13 104.24,77.17 123.69,77.17 124.18,76.69 124.18,72.88 125.96,71.1 125.96,68.31 126.74,67.52 134.24,67.52 134.6,67.16 134.6,57.98 133.47,56.85
+VCC_CORE on GND3: 91.77,61.05 91.42,61.4 91.42,67.16 96.35,72.09 104.98,72.09 108.16,75.27 112.9,75.27 118.61,69.56 118.61,68.67 119.63,67.65 127.33,67.65 128.35,68.67 134.49,68.67 134.6,68.56 134.6,65.6 132.45,63.46 118.32,63.46 114.89,66.89 107.69,66.89 106.8,66 99.09,66 94.13,61.05
+VCC_EDRAM on TOP (solid shape): outline of 132 points within 116.71,60.92 122.78,64.91
+VCC_EDRAM on BOTTOM (solid shape): 96.34,39.84 96.34,38.03 96.19,37.88 94.9,37.88 94.69,38.09 94.69,39.85 94.82,39.97 96.2,39.97
+VCC_EDRAM on BOTTOM (solid shape): 118.08,64.88 118.08,61.17 117.88,60.97 117.5,60.97 117.29,61.04 117.08,60.97 117.01,61.05 117.01,61.17 117.39,61.56 117.83,62 117.83,62.63 117.64,62.82 117.59,62.82 117.58,62.83 117.42,62.87 117.27,62.83 117.25,62.82 117.07,62.82 117.01,62.89 117.01,63.01 117.45,63.46 117.45,64.09 117.35,64.19 117.35,64.24 117.06,64.53 117.01,64.53 117.01,64.54 117.01,64.86 117.07,64.92 118.05,64.92
+VCC_EDRAM on GND3: 92.79,37.3 91.92,38.16 91.92,43.41 93.57,45.06 93.57,60.54 94.34,60.54 99.3,65.49 107.01,65.49 107.9,66.38 114.68,66.38 118.11,62.95 118.34,62.95 118.34,60.52 116.58,58.76 111.59,58.76 109.43,60.92 99.44,60.92 96.62,58.1 96.62,37.66 96.26,37.3
+VCC_EDRAM_P on BOTTOM (solid shape): 95.84,41.13 96.26,41.13 96.36,41.03 96.36,40.22 96.29,40.15 94.78,40.15 94.59,40.34 91.86,40.34 91.31,39.79 91.31,39.6 91.24,39.53 90.48,39.53 90.42,39.6 90.42,40.37 92.39,42.34 94.62,42.34
+VCC_EOPIO on TOP (solid shape): 119.99,60.92 119.99,60.28 119.86,60.16 119.36,60.16 118.72,59.52 118.72,58.76 118.97,58.51 118.97,58.25 118.72,58 118.11,58 118.04,58.03 118.01,58.1 117.65,58.45 117.3,58.1 117.27,58.03 117.2,58 116.94,58 116.65,58.29 116.66,58.32 116.67,58.51 116.58,58.68 116.56,58.7 116.56,58.82 116.62,58.82 117.21,59.42 117.3,59.44 117.38,59.38 117.88,59.21 117.99,59.74 117.98,59.85 118.07,59.9 118.09,59.9 118.34,60.16 118.34,60.66 118.72,61.04 119.86,61.04
+VCC_EOPIO on BOTTOM (solid shape): 93.4,35.39 93.4,34.25 93.16,34.01 90.72,34.01 90.53,34.2 90.53,35.39 90.81,35.67 93.12,35.67
+VCC_EOPIO on BOTTOM (solid shape): 117.37,59.4 117.37,59.39 117.59,59.18 117.89,59.22 118.08,59.22 118.08,58.79 118.02,58.79 117.68,58.45 117.6,58.45 117.52,58.43 117.45,58.43 117.37,58.35 117.37,58.35 117.24,58.23 117.09,58.23 116.99,58.33 116.99,59.37 117.09,59.47 117.3,59.47
+VCC_EOPIO on GND2 (solid shape): outline of 3428 points within 91.03,35.01 119.48,64.47
+VCC_EOPIO_P on TOP (solid shape): 92.42,32.16 92.42,31.35 92.32,31.25 88.93,31.25 88.67,31.52 88.67,32.33 88.74,32.4 92.19,32.4
+VCC_EOPIO_P on BOTTOM (solid shape): 92.74,33.14 92.74,29.84 92.49,29.59 91.77,29.59 91.32,30.05 88.96,30.05 88.52,30.49 87.3,30.49 87.26,30.53 87.26,30.68 87.32,30.74 87.43,30.74 88.05,31.36 88.05,32.06 88.46,32.47 90.64,32.47 91.06,32.89 91.07,32.89 91.07,32.9 91.38,33.21 92.67,33.21
+VCC_GT on TOP (solid shape): 122.59,73.87 122.81,73.8 123.03,73.87 124.05,73.87 124.3,73.63 124.27,73.6 124.27,73.19 124.64,73.04 124.73,73.02 124.77,72.94 124.77,72.68 124.66,72.58 121.5,72.58 121.42,72.61 121.39,72.68 121.04,73.06 120.68,72.68 120.66,72.61 120.58,72.58 114.66,72.58 114.35,72.88 114.35,73.3 114.83,73.78 117.81,73.78 117.89,73.73 117.89,73.63 118.2,73.09 118.51,73.63 118.51,73.73 118.6,73.78 119.12,73.78 119.2,73.73 119.21,73.64 119.55,73.17 119.89,73.64 119.9,73.73 119.98,73.78 121.79,73.78 121.89,73.87
+VCC_GT on TOP (solid shape): outline of 6657 points within 89.89,44.15 127.36,68.04
+VCC_GT on BOTTOM (solid shape): outline of 1244 points within 118.21,55.46 128.8,58.32
+VCC_GT on BOTTOM (solid shape): outline of 2405 points within 90.02,44.15 127.23,68.21
+VCC_GT on IN2 (solid shape): outline of 3098 points within 89.51,44.03 127.74,67.36
+VCC_GT on IN3 (solid shape): 124.12,73.62 124.2,73.58 124.22,73.49 124.32,73.13 124.68,73.05 124.77,73.04 124.82,72.96 124.82,72.48 124.71,72.37 121.62,72.37 121.39,72.6 121.4,72.71 121.39,72.78 121.39,73.35 123.16,73.35 123.43,73.62
+VCC_GT on IN3 (solid shape): outline of 5481 points within 88.37,44.15 126.98,66.13
+VCC_GT on IN4 (solid shape): outline of 3591 points within 89.89,43.65 126.98,73.24
+VCC_GT on VCC: 89.36,44.15 89,44.51 89,60.16 94.01,60.16 97.31,63.46 115.95,63.46 116.71,62.7 117.6,62.7 117.85,62.44 126.36,62.44 126.72,62.08 126.72,56.66 125.12,56.66 124.86,56.41 117.24,56.41 117.17,56.47 114,56.47 109.68,60.79 102.1,60.79 96.62,55.31 96.62,44.15
+VCC_SA on TOP (solid shape): 79.15,64.4 79.15,63.43 79.1,63.38 79.1,61.48 79.04,61.43 78.79,61.43 78.46,61.1 78.46,60.77 78.08,60.38 75.95,60.38 75.72,60.61 75.72,64.3 76.05,64.63 78.92,64.63
+VCC_SA on BOTTOM (solid shape): 137.97,58.15 137.95,58.12 138.03,57.72 138.43,57.65 138.46,57.66 138.56,57.56 138.56,57.53 138.57,57.39 138.63,57.26 138.63,56.9 138.56,56.83 137.44,56.83 137.36,56.9 137.36,58.12 137.47,58.23 137.9,58.23
+VCC_SA on BOTTOM (solid shape): 77.85,68.54 77.85,65.76 77.85,65.27 78.34,65.25 78.41,65.27 78.48,65.24 78.68,65.04 78.69,65.03 78.81,64.87 79,64.8 79.07,64.76 79.1,64.69 79.1,64.28 79.03,64.08 79.1,63.88 79.1,61.05 78.4,60.35 75.98,60.35 75.79,60.54 75.79,61.3 76.37,61.87 76.37,62.76 76.18,62.95 76.18,65.06 76.21,65.14 76.29,65.16 76.71,65.52 76.29,65.87 76.21,65.89 76.18,65.97 76.18,68.61 76.35,68.79 77.6,68.79
+VCC_SA on BOTTOM (solid shape): outline of 374 points within 134.66,66.38 139.04,68.73
+VCC_SA on IN1 (solid shape): outline of 187 points within 135.61,57.62 138.02,63.59
+VCC_SA on VCC: 71.33,60.28 70.84,60.77 70.84,80.73 139.93,80.73 139.93,67.75 139.29,67.12 139.29,63.33 135.1,63.33 135.1,67.37 134.45,68.03 126.95,68.03 126.47,68.52 126.47,71.31 124.69,73.09 124.69,76.9 123.91,77.68 103.73,77.68 103.73,74.63 93.34,74.63 88.49,69.79 88.49,60.28
+VCCPLL_OC on TOP (solid shape): 159.87,48.09 159.87,47.08 160.02,46.92 160.02,45.99 159.9,45.87 159.82,45.74 159.79,45.58 159.79,45.56 159.73,45.5 159.03,45.5 158.22,46.31 158.22,47.15 158.88,47.81 158.88,48.12 158.95,48.19 159.77,48.19
AGND on TOP (solid shape): 21.87,33.31 21.87,32.78 21.57,32.48 21.57,31.07 21.44,30.95 20.93,30.95 20.68,30.69 20.17,30.69 20.04,30.82 20.04,33.49 20.3,33.74 21.44,33.74
AGND on TOP (solid shape): 22.45,23.26 22.45,22.06 22.39,21.99 21.95,21.99 21.95,22.56 21.44,22.56 21.44,21.99 20.8,21.99 20.55,22.25 20.55,23.14 20.8,23.39 22.33,23.39
AGND on BOTTOM (solid shape): 7.34,22.56 7.34,21.17 7.06,20.88 5.17,20.88 5.1,20.95 5.1,21.31 5.66,21.31 5.66,21.8 5.1,21.8 5.1,22.42 5.38,22.69 7.21,22.69
AGND on GND1, GND2, GND3: 5.8,21.04 5.31,21.53 5.31,23.94 4.65,24.6 1.26,24.6 1.26,25.86 1.33,26.03 1.5,26.11 12.72,26.11 13.46,26.73 12.98,27.57 12.98,32.95 13.46,33.79 12.72,34.42 1.5,34.42 1.33,34.49 1.26,34.66 1.26,36.03 24.97,36.03 25.23,36.28 29.59,36.28 30.07,35.79 30.07,32.45 29.97,32.34 25.4,32.34 24.99,31.94 24.99,28.77 24.95,28.72 21.52,28.72 20.93,28.13 20.93,26.14 21.59,25.49 25.23,25.49 25.88,26.14 25.88,26.97 25.92,27.01 26.6,27.01 26.62,26.99 26.62,24.75 25.83,23.96 25.83,23.05 25.09,22.31 21.02,22.31 19.75,21.04
AGND on VCC: 5.8,21.04 5.31,21.53 5.31,23.94 4.65,24.6 2.27,24.6 2.27,25.09 12.72,25.09 14.35,26.17 13.99,28.09 13.99,32.43 14.35,34.35 12.72,35.43 2.27,35.43 2.27,36.03 24.97,36.03 25.23,36.28 29.59,36.28 30.07,35.79 30.07,32.45 29.97,32.34 25.4,32.34 24.99,31.94 24.99,28.77 24.95,28.72 21.52,28.72 20.93,28.13 20.93,26.14 21.59,25.49 25.23,25.49 25.88,26.14 25.88,26.97 25.92,27.01 26.6,27.01 26.62,26.99 26.62,24.75 25.83,23.96 25.83,23.05 25.09,22.31 21.02,22.31 19.75,21.04
GND on TOP (solid shape): 29.08,49.18 29.08,48.57 28.66,48.16 25.76,48.16 25.63,48.29 25.63,49.22 25.9,49.49 28.77,49.49
GND on TOP (solid shape): 60.17,38.82 60.17,37.8 60.05,37.68 58.87,37.68 58.4,38.15 58.4,38.82 58.52,38.95 60.05,38.95
GND on TOP (solid shape): 166.09,32.09 166.09,29.42 165.71,29.04 165.08,29.04 164.95,29.17 164.95,32.09 165.08,32.22 165.96,32.22
GND on TOP (solid shape): 86.65,42.53 86.65,41.8 86.84,41.61 86.84,41.3 85.95,41.3 85.83,41.42 85.83,42.5 85.89,42.57 86.61,42.57
GND on TOP (solid shape): 6.33,20.66 6.33,20.53 6.2,20.41 5.82,20.41 5.69,20.53 4.42,20.53 4.29,20.66 4.29,20.91 4.42,21.04 5.94,21.04
GND on TOP (solid shape): 53.94,80.54 53.94,79.78 53.65,79.5 53.65,78.32 53.39,78.06 52.05,78.06 51.79,78.32 51.79,80.6 51.92,80.73 53.75,80.73
GND on TOP (solid shape): 146.15,79.21 146.15,77.81 145.81,77.46 140.2,77.46 140,77.66 135.08,77.66 134.98,77.76 134.98,79.46 135.1,79.59 145.77,79.59
GND on TOP (solid shape): 21.76,21.8 22.26,21.8 22.45,21.61 22.45,21.1 22.26,20.91 20.61,20.91 20.55,20.98 20.55,21.61 20.74,21.8 21.63,21.8 21.63,22.37 21.76,22.37
GND on TOP (solid shape): 72.49,45.42 72.49,44.28 72.37,44.15 71.48,44.15 71.35,44.28 71.35,45.04 71.1,45.3 71.1,45.55 71.22,45.68 72.24,45.68
GND on TOP (solid shape): 75.54,38.82 75.54,36.41 76.05,35.9 76.05,34.63 75.92,34.5 74.14,34.5 74.02,34.63 74.02,39.07 74.14,39.2 75.16,39.2
GND on TOP (solid shape): 74.52,30.18 74.52,29.68 74.4,29.55 74.14,29.55 73.25,28.66 67.22,28.66 67.03,28.85 67.03,30.06 67.22,30.25 74.46,30.25
GND on TOP (solid shape): 196.7,54.19 196.7,53.3 196.44,53.04 195.68,53.04 195.56,52.92 195.56,52.41 195.43,52.28 194.03,52.28 193.9,52.41 193.9,54.06 194.07,54.22 194.07,54.6 194.16,54.7 196.19,54.7
GND on TOP (solid shape): 197.59,62.82 197.59,61.68 196.95,61.05 196.95,58.19 196.83,58.07 194.1,58.07 194.07,58.1 194.07,59.94 194.92,60.79 194.92,62.32 195.05,62.44 195.81,62.44 196.32,62.95 197.46,62.95
GND on TOP (solid shape): 53.44,49.49 53.44,48.54 53.44,48.41 53.44,47.27 53.44,45.81 53.2,45.56 52.26,45.56 52.1,45.72 52.1,47.07 52.17,47.14 52.17,49.55 52.24,49.62 53.32,49.62
GND on TOP (solid shape): 78.33,23.2 78.33,19.77 78.08,19.52 75.16,19.52 74.91,19.77 74.91,23.07 75.16,23.33 78.21,23.33
GND on TOP (solid shape): 90.65,41.36 90.65,41.11 90.15,40.6 90.15,38.19 90.02,38.06 88.06,38.06 88.06,38.06 87.79,38.06 87.73,38.12 87.73,40.6 87.86,40.73 89.26,40.73 89.51,40.98 89.51,41.36 89.64,41.49 90.53,41.49
GND on TOP (solid shape): 174.32,52.43 174.35,52.35 174.35,50.93 174.56,50.72 175.32,50.72 175.32,49.02 173.62,49.02 173.62,50.96 173.6,50.98 173.6,52.42 173.71,52.54 174.22,52.54
GND on TOP (solid shape): 67.54,65.87 69.7,65.87 69.95,65.62 69.95,63.71 69.19,62.95 66.02,62.95 65.76,63.2 65.76,64.35 65.89,64.47 66.52,64.47 67.29,65.24 67.29,65.62 67.03,65.87 67.03,66 67.41,66
GND on TOP (solid shape): 197.55,26.89 197.55,26.48 197.71,26.32 197.71,26.31 197.73,26.2 197.79,26.11 197.79,25.7 197.68,25.59 196.77,25.59 196.67,25.7 195.94,25.7 195.85,25.78 195.85,26.86 196.05,27.07 197.38,27.07
GND on TOP (solid shape): 53.32,38.06 53.32,35.65 53.19,35.52 53.19,30.57 53.06,30.44 52.05,30.44 51.66,30.82 51.66,35.57 51.66,35.57 51.66,35.77 51.54,35.9 51.54,37.13 51.54,37.13 51.54,37.93 51.61,38.01 51.64,38.01 51.64,38.03 51.79,38.19 53.19,38.19
GND on TOP (solid shape): 64.87,43.27 69.19,43.27 69.44,43.01 69.44,39.84 69.32,39.71 66.65,39.71 66.02,40.34 65.63,40.34 65.38,40.09 64.87,40.09 62.97,42 62.97,43.52 63.09,43.65 64.49,43.65
GND on TOP (solid shape): 31.11,56.18 31.11,52.84 30.82,52.54 30.82,49.1 30.73,49.02 29.85,49.02 29.82,49.04 29.82,49.23 29.07,49.98 29.07,53.01 29.07,53.02 29.07,53.51 29.95,54.39 29.95,54.42 29.95,54.42 29.95,55.62 29.69,55.89 29.69,56.2 29.8,56.32 29.83,56.33 30.96,56.33
GND on TOP (solid shape): 92.43,21.8 94.59,21.8 94.72,21.68 94.72,20.02 93.98,19.29 92.92,19.29 92.18,20.02 91.8,20.02 91.16,19.39 89.38,19.39 89.13,19.64 89.13,21.55 89.36,21.78 90.78,21.78 91.44,22.44 91.8,22.44
GND on TOP (solid shape): 168.38,37.04 168.38,33.74 168.5,33.61 169.06,33.61 169.49,33.19 169.49,31.12 168.55,31.12 168.55,32.93 168.38,33.11 167.87,33.11 167.23,33.74 167.23,34.1 167.03,34.3 166.93,34.3 166.73,34.5 166.73,34.91 166.4,35.24 166.4,36.71 166.98,37.3 168.12,37.3
GND on TOP (solid shape): 173.08,77.56 173.08,76.93 173.04,76.9 173.04,75.97 173.13,75.88 174.02,75.88 174.02,74.18 173.25,74.18 173.04,73.97 173.04,73.02 173.2,72.86 173.2,72.6 173.08,72.48 172.82,72.48 172.7,72.6 172.7,72.89 172.79,72.99 172.79,74.08 172.69,74.18 172.32,74.18 172.32,76.03 171.86,76.49 171.86,77.52 171.96,77.62 173.01,77.62
GND on TOP (solid shape): 19.28,57.74 19.28,56.85 19.19,56.76 18.41,56.76 18.13,56.79 17.92,56.6 17.63,56.31 17.63,54.69 17.5,54.57 16.49,54.57 16.36,54.7 16.36,55.71 16.23,55.84 16.23,57.02 17.2,57.02 18.05,57.87 19.15,57.87
GND on TOP (solid shape): 168.34,44.66 168.34,43.09 168.45,42.99 169.32,42.99 169.32,41.28 168.55,41.28 168.34,41.07 168.34,40 168.49,39.85 168.49,39.75 168.5,39.73 168.5,39.58 168.38,39.46 168.12,39.46 168,39.58 168,39.88 168.09,39.98 168.09,41.14 167.95,41.28 167.62,41.28 167.62,43.01 167.62,43.01 167.62,43.16 167.5,43.28 167.5,44.14 167.23,44.41 167.23,44.66 167.39,44.81 168.19,44.81
GND on TOP (solid shape): 199.9,76.64 199.9,75.62 200.03,75.5 200.88,75.5 200.88,73.8 200.1,73.8 199.92,73.62 199.92,71.97 199.82,71.87 199.59,71.87 199.47,71.99 199.47,72.3 199.53,72.37 199.53,72.39 199.64,72.5 199.64,73.62 199.47,73.8 199.17,73.8 199.17,75.51 198.97,75.71 198.6,75.71 198.58,75.74 198.58,76.02 198.69,76.22 198.66,76.45 198.66,76.49 198.86,76.69 199.85,76.69
GND on TOP (solid shape): 133.38,64.03 133.38,63.52 133.33,63.46 132.56,63.46 132.27,63.16 132.08,62.9 132.18,62.6 132.18,61.43 132.44,61.17 133.2,61.17 133.33,61.05 133.33,60.66 133.2,60.54 128.54,60.54 128.5,60.58 128.5,61.12 128.55,61.17 129.39,61.17 129.64,61.43 129.64,63.08 129.39,63.33 128.75,63.33 128.63,63.46 128.63,63.97 128.75,64.09 133.33,64.09
GND on TOP (solid shape): 26.52,77.17 26.52,75.9 26.77,75.65 29.74,75.65 30.54,74.85 30.54,74.82 30.67,74.47 31.04,74.43 31.05,74.43 31.17,74.43 31.41,74.19 31.41,73.72 31.18,73.49 29.15,73.49 28.69,73.95 28.19,73.95 27.64,73.39 26.57,73.39 26.45,73.5 26.45,74.08 26.02,74.51 23.98,74.51 23.77,74.72 23.77,76.55 24.01,76.79 25.18,76.79 25.42,77.03 25.42,77.19 25.53,77.3 26.39,77.3
GND on TOP (solid shape): 82.59,34.2 82.75,34.16 82.91,34.2 82.92,34.21 83.69,34.21 83.78,34.12 83.78,32.32 84.32,31.78 84.45,31.78 84.52,31.77 84.59,31.78 85.9,31.78 87.22,33.1 87.73,33.1 87.8,33.17 87.85,33.21 87.88,33.25 88.38,33.75 89.85,33.75 89.98,33.63 89.98,32.73 89.79,32.55 88.54,32.55 87.1,31.1 87.1,29.55 86.72,29.17 84.43,29.17 84.05,29.55 84.05,31.07 83.8,31.33 81.64,31.33 81.38,31.58 81.38,33.53 81.85,33.99 81.85,33.99 82.07,34.21 82.58,34.21
GND on TOP (solid shape): 46.4,42.5 46.58,42.45 46.77,42.5 50.14,42.5 50.39,42.25 50.39,42 50.14,41.74 48.36,41.74 48.11,41.49 48.11,38.19 48.74,37.55 48.74,37.04 48.62,36.92 48.11,36.92 47.85,37.17 46.43,37.17 46.16,37.33 45.88,37.19 45.75,37.19 45.2,37.73 45.2,37.75 44.96,37.99 44.63,37.92 44.59,37.91 44.56,37.93 44.3,38.19 44.3,39.46 43.79,39.96 43.79,40.34 44.43,40.98 44.43,42.31 44.61,42.5
GND on TOP (solid shape): 135.9,67.23 135.9,67.22 136.17,66.71 136.57,67.12 136.57,67.14 136.82,67.4 137.01,67.4 137.26,67.14 137.26,66.89 137.2,66.82 136.75,66.38 136.75,63.03 136.7,62.96 136.66,62.87 136.66,62.86 136.25,62.44 135.48,62.44 135.23,62.19 135.23,61.68 136.88,60.03 136.98,60.03 137.16,59.85 137.16,59.29 137.01,59.14 133.96,59.14 133.83,59.27 133.83,59.78 133.96,59.9 134.74,59.9 134.86,60.02 134.86,65.58 134.9,65.62 134.9,66.14 135.01,66.25 135.1,66.25 135.23,66.38 135.23,66.89 135.1,67.01 135.1,67.27 135.23,67.4 135.9,67.4
GND on TOP (solid shape): 22.59,63.19 22.59,63.16 22.71,63.04 22.71,62.82 22.84,62.7 24.11,62.7 24.23,62.57 24.23,62.44 24.26,62.41 24.27,62.4 24.33,62.29 24.44,62.23 24.45,62.23 24.49,62.19 24.7,62.19 24.71,62.16 24.74,62.11 24.77,62.06 24.79,62 24.77,61.93 24.73,61.87 24.7,61.79 24.65,61.73 24.58,61.72 24.26,61.51 24.51,61.22 24.53,61.22 24.68,61.07 25.61,61.07 25.63,61.05 25.63,60.92 25.42,60.71 25.41,60.71 25.33,60.65 25.27,60.57 25.27,60.56 24.99,60.28 23.22,60.28 22.93,60.56 22.93,60.57 22.75,60.77 22.49,60.79 22.45,60.79 22.43,60.77 22.27,60.6 22.25,60.37 22.26,60.34 22.2,60.28 21.82,60.28 21.74,60.36 21.75,60.39 21.76,60.53 21.69,60.65 21.69,60.79 22.06,61.16 22.43,61.16 22.44,61.17 22.71,61.17 22.84,61.3 22.84,62.06 22.58,62.32 21.95,62.32 21.82,62.44 21.82,62.72 21.85,62.79 21.92,62.82 22.16,62.92 22.28,63.16 22.28,63.2 22.58,63.2
GND on TOP (solid shape): outline of 164 points within 79.73,35.9 85.66,66
GND on TOP (solid shape): outline of 166 points within 118.27,57.87 129.52,66.94
GND on TOP (solid shape): outline of 249 points within 0.65,0.39 217.56,81.75
GND on BOTTOM (solid shape): 2.59,22.46 1.55,22.46 1.55,24.11 2.59,24.11
GND on BOTTOM (solid shape): 2.59,18.61 1.55,18.61 1.55,20.26 2.59,20.26
GND on BOTTOM (solid shape): 4.93,22.18 4.93,20.66 4.8,20.53 4.29,20.53 4.04,20.79 4.04,21.93 4.42,22.31 4.8,22.31
GND on BOTTOM (solid shape): 5.18,23.83 5.18,22.82 5.06,22.69 4.29,22.69 4.17,22.82 4.17,23.83 4.29,23.96 5.06,23.96
GND on BOTTOM (solid shape): 60.3,38.44 60.3,37.55 60.17,37.42 58.52,37.42 58.4,37.55 58.4,38.44 58.52,38.57 60.17,38.57
GND on BOTTOM (solid shape): 75.79,68.59 75.79,65.36 75.54,65.11 74.4,65.11 74.27,65.24 74.27,68.28 74.75,68.77 75.62,68.77
GND on BOTTOM (solid shape): 85.57,17.74 85.57,16.34 85.45,16.21 84.43,16.21 84.3,16.34 84.3,17.74 84.43,17.87 85.45,17.87
GND on BOTTOM (solid shape): 196.7,54.19 196.7,53.17 196.57,53.04 194.29,53.04 193.9,53.43 193.9,54.44 194.16,54.7 196.19,54.7
GND on BOTTOM (solid shape): 46.81,27.84 47.87,27.84 47.95,27.77 47.95,26.35 47.83,26.23 46.67,26.23 46.35,26.55 46.35,27.77 46.45,27.87 46.78,27.87
GND on BOTTOM (solid shape): 75.54,38.82 75.54,36.41 76.51,35.43 76.51,34.66 76.36,34.5 74.14,34.5 74.02,34.63 74.02,39.07 74.14,39.2 75.16,39.2
GND on BOTTOM (solid shape): 23.04,52.66 23.04,50.22 22.9,50.08 22.13,50.08 22.07,50.14 22.07,51.23 21.45,51.85 20.42,51.85 20.26,52.01 20.26,52.65 20.42,52.8 22.91,52.8
GND on BOTTOM (solid shape): 191.56,78.64 192.24,78.64 192.48,78.4 192.48,77.14 192.38,77.04 190.92,77.04 190.55,77.41 190.55,78 190.31,78.25 190.31,78.82 190.41,78.92 191.28,78.92
GND on BOTTOM (solid shape): 184,23.83 184,21.68 183.87,21.55 182.15,21.55 182.1,21.6 181.16,21.6 181.11,21.55 180.82,21.55 180.7,21.68 180.7,23.33 181.08,23.71 182.22,23.71 182.47,23.96 183.87,23.96
GND on BOTTOM (solid shape): 204.45,67.52 204.45,66.51 204.32,66.38 203.81,66.38 203.56,66.63 202.54,66.63 202.29,66.38 202.29,65.87 202.16,65.74 201.52,65.74 201.4,65.87 201.4,67.4 202.03,68.03 203.94,68.03
GND on BOTTOM (solid shape): 207.37,16.34 207.37,14.44 207.24,14.31 200.51,14.31 200.38,14.44 200.38,16.09 200.75,16.45 202.17,16.45 202.41,16.21 204.06,16.21 204.1,16.25 204.14,16.25 204.49,16.6 207.11,16.6
GND on BOTTOM (solid shape): 54.13,49.74 55.22,49.74 55.47,49.49 55.47,47.41 55.37,47.31 54.89,46.82 54.89,46.2 54.87,46.18 53.79,46.18 53.15,45.53 52.22,45.53 52.06,45.69 52.06,49.03 52.91,49.87 54,49.87
GND on BOTTOM (solid shape): 95.85,42.86 95.91,42.86 98.81,42.86 99.04,42.63 99.04,41.49 98.78,41.23 96.34,41.23 96.32,41.25 95.97,41.25 95.23,42 95.23,42.5 95.61,42.88 95.77,42.88
GND on BOTTOM (solid shape): 30.46,23.33 31.85,23.33 32.11,23.07 32.11,21.93 31.85,21.68 31.09,21.68 29.57,20.15 29.31,20.15 29.06,20.41 29.06,21.8 29.19,21.93 29.19,23.45 29.31,23.58 30.2,23.58
GND on BOTTOM (solid shape): 202.54,75.22 202.54,73.69 202.44,73.59 201.93,73.59 201.73,73.39 201.73,73.08 201.61,72.97 201,72.97 200.61,73.36 199.11,73.36 198.98,73.49 198.98,74.84 199.47,75.32 202.44,75.32
GND on BOTTOM (solid shape): 72.72,78.06 72.75,78.06 72.87,77.94 72.87,77.2 72.31,76.64 71.27,76.64 71.15,76.77 71.15,77.15 71.25,77.25 71.91,77.25 72.08,77.43 72.16,77.49 72.22,77.57 72.31,77.66 72.31,78.01 72.42,78.11 72.66,78.11
GND on BOTTOM (solid shape): 101.83,68.41 105.05,68.41 105.49,67.98 105.49,66.48 105.26,66.25 101.7,66.25 100.56,65.11 100.56,64.09 100.39,63.93 98.95,63.93 98.88,63.99 98.88,64.02 98.86,64.17 98.78,64.29 98.78,69.68 99.04,69.94 100.31,69.94
GND on BOTTOM (solid shape): 26.13,31.76 26.64,31.76 26.64,31.84 29.69,31.84 29.95,31.58 29.95,29.05 30.15,28.85 31.04,28.85 31.22,28.67 31.22,27.57 31.06,27.42 29.79,27.42 29.34,26.96 27.46,26.96 27.15,27.26 25.12,27.26 24.99,27.39 24.99,31.2 25.55,31.76 25.89,31.76 25.89,31.84 26.13,31.84
GND on BOTTOM (solid shape): 78.39,23.14 78.39,19.93 77.98,19.52 72.37,19.52 72.11,19.77 72.11,23.07 72.24,23.2 74.91,23.2 75.03,23.07 75.03,22.44 75.29,22.18 76.43,22.18 76.63,22.39 76.63,23.15 76.81,23.33 78.21,23.33
GND on BOTTOM (solid shape): 69.95,65.62 69.95,64.6 69.85,64.5 67.95,64.5 67.92,64.47 67.92,64.26 67.79,64.13 67.79,63.06 67.66,62.93 67.47,62.93 67.42,62.98 66.05,62.98 65.76,63.26 65.76,64.45 65.88,64.56 66.43,64.56 66.6,64.73 66.76,64.73 67.28,65.25 67.28,65.69 67.46,65.87 69.7,65.87
GND on BOTTOM (solid shape): 99.92,54.44 99.92,52.28 100.56,51.65 100.56,47.37 100.51,47.18 100.56,46.99 100.56,46.57 99.92,45.93 99.29,45.93 98.91,46.31 98.91,48.73 97.77,49.87 97.77,52.66 97.38,53.04 96.37,53.04 96.24,53.17 96.24,54.57 96.37,54.7 99.67,54.7
GND on BOTTOM (solid shape): 94.84,21.66 94.84,19.9 94.34,19.39 93.02,19.39 91.77,20.63 90.88,20.63 90.65,20.41 90.65,20.02 90.46,19.83 89.57,19.83 88.77,20.63 87.84,20.63 87.78,20.69 87.78,20.81 87.85,20.89 88.91,20.89 89.28,21.26 90.88,21.26 90.96,21.34 91.71,21.34 92.29,21.92 94.59,21.92
GND on BOTTOM (solid shape): 69.44,43.01 69.44,38.82 69.19,38.57 68.56,38.57 68.17,38.95 68.17,39.71 67.79,40.09 67.03,40.09 66.14,40.98 66.14,42 65.79,42.35 64.35,42.35 63.98,41.98 62.98,41.98 62.61,42.35 61.54,42.35 61.32,42.12 61.06,42.12 60.94,42.25 60.94,42.5 61.04,42.6 62.62,42.6 62.99,42.97 64.58,42.97 64.66,43.05 65.89,43.05 65.97,43.14 69.32,43.14
GND on BOTTOM (solid shape): 53.32,38.06 53.32,37.1 53.19,36.98 52.36,36.98 52.36,35.84 52.87,35.84 52.87,35.83 53.05,35.83 53.19,35.69 53.19,33.49 53.53,33.14 54.55,33.14 54.59,33.11 54.59,31.07 53.95,30.44 52.05,30.44 51.66,30.82 51.66,35.57 51.66,35.62 51.38,35.91 51.1,35.91 51.06,35.95 51.06,37.45 51.79,38.19 53.19,38.19
GND on BOTTOM (solid shape): 9.98,25.77 10,25.74 10.01,25.74 14.45,21.29 14.45,20.02 14.33,19.9 13.18,19.9 12.93,20.15 12.93,20.66 8.99,24.6 8.94,24.6 8.92,24.61 8.69,24.72 8.44,24.65 8.41,24.63 8.38,24.65 8.32,24.68 8.24,24.71 7.98,24.98 7.98,25.99 8.09,26.11 9.64,26.11
GND on BOTTOM (solid shape): 200.55,61.81 200.32,61.81 200.32,63.13 198.62,63.13 198.62,61.81 198.6,61.81 198.22,61.43 197.5,61.43 196.95,60.87 196.95,58.31 196.71,58.07 194.1,58.07 193.99,58.18 193.99,59.5 194.16,59.67 194.54,59.67 194.56,59.65 195.17,59.65 195.43,59.9 195.43,60.54 195.17,60.79 194.41,60.79 194.29,60.92 194.29,61.43 194.92,62.06 194.92,62.32 195.05,62.44 195.81,62.44 195.94,62.57 197.21,62.57 197.97,63.33 197.97,63.59 198.07,63.69 200.55,63.69
GND on BOTTOM (solid shape): 184.49,42.77 184.4,42.54 184.51,42.32 184.51,41.37 184.51,41.37 184.53,41.2 184.63,41.06 184.63,40.85 184.46,40.68 184.43,40.7 184.2,40.72 184.01,40.6 180.82,40.6 180.57,40.85 180.57,42.09 180.62,42.27 180.57,42.46 180.57,43.39 180.82,43.65 183.62,43.65
GND on BOTTOM (solid shape): 95.24,43.26 95.24,42.7 95.01,42.47 92.31,42.47 92.28,42.44 92.24,42.44 92.24,42.4 90.19,40.34 90.19,38.09 90.16,38.06 88.46,38.06 88.46,39.76 89.18,39.76 89.43,40.01 89.43,41.5 89.27,41.67 87.31,41.67 86.9,41.26 85.95,41.26 85.82,41.39 85.82,42.49 85.87,42.54 89.96,42.54 90.6,41.9 90.8,41.9 91.18,41.83 91.4,42.15 91.4,42.17 91.42,42.19 91.42,42.99 91.44,42.99 91.44,43.53 91.65,43.74 94.76,43.74
GND on BOTTOM (solid shape): 69.86,30.31 70.03,30.27 70.19,30.31 70.2,30.31 70.58,30.31 70.78,30.25 70.98,30.31 71.81,30.31 71.81,30.31 71.95,30.28 72.08,30.31 72.09,30.31 72.47,30.31 72.48,30.31 72.63,30.27 72.79,30.31 72.8,30.31 73.38,30.31 73.64,30.06 73.64,29.04 73.25,28.66 72.29,28.66 72.28,28.67 71.84,28.67 71.73,28.79 69.26,28.79 67.29,28.79 67.03,29.04 67.03,30.06 67.29,30.31 69.85,30.31
GND on BOTTOM (solid shape): 70.84,55.46 70.84,54.7 70.61,54.47 70.59,54.47 70.59,54.25 70.09,54.25 69.49,54.06 70.09,53.87 70.59,53.87 70.59,53.65 70.74,53.65 70.84,53.55 71.35,53.55 71.48,53.43 71.48,51.14 71.22,50.89 68.81,50.89 68.56,51.14 66.4,51.14 66.15,51.39 66.15,52.93 66.14,52.93 66.14,53.43 67.29,54.57 67.29,54.92 67.29,54.92 67.29,55.46 67.54,55.71 70.59,55.71
GND on BOTTOM (solid shape): 64.24,28.41 64.24,23.4 64.2,23.32 64.12,23.3 63.73,22.95 64.12,22.59 64.38,22.59 64.5,22.46 64.5,21.92 63.16,20.57 58.93,20.57 58.89,20.53 58.4,20.53 57.89,20.02 55.35,20.02 55.22,20.15 55.22,22.08 55.27,22.26 55.22,22.44 55.22,22.96 55.27,23.13 55.24,23.3 55.22,23.33 55.86,23.96 57.76,23.96 58.4,24.6 58.4,28.41 58.65,28.66 63.98,28.66
GND on BOTTOM (solid shape): 52.17,19.26 52.84,19.26 52.86,19.24 52.89,19.2 52.93,19.17 52.97,19.14 53.02,19.12 53.07,19.11 53.12,19.1 53.31,19.1 53.41,19.01 53.41,17.96 53.3,17.85 50.99,17.85 49.1,15.96 46.84,15.96 46.58,16.21 46.58,17.99 49.35,17.99 49.35,17.94 49.36,17.89 49.38,17.84 49.4,17.79 49.43,17.74 49.47,17.71 49.51,17.67 49.55,17.65 49.6,17.63 49.66,17.61 49.71,17.61 49.76,17.61 49.81,17.63 49.86,17.65 49.91,17.67 49.95,17.71 49.99,17.74 50.02,17.79 50.04,17.84 50.06,17.89 50.06,17.94 50.06,17.99 50.06,18.05 50.04,18.1 50.02,18.14 49.99,18.19 49.95,18.23 49.91,18.26 49.86,18.29 49.81,18.31 49.76,18.32 49.71,18.32 49.66,18.32 49.6,18.31 49.55,18.29 49.51,18.26 49.47,18.23 49.43,18.19 49.4,18.14 49.38,18.1 49.36,18.05 49.35,17.99 46.58,17.99 46.58,19.52 46.71,19.64 47.85,19.64 48.49,19.01 49.63,19.01 50.65,20.02 51.41,20.02
GND on BOTTOM (solid shape): 91.02,33.64 91.02,33.03 90.66,32.67 88.42,32.67 87.82,32.08 87.82,31.53 87,30.72 87,29.01 85.3,29.01 85.3,30.72 86.11,30.72 86.27,30.88 86.27,32.76 86.09,32.95 86.07,32.95 85.91,33 85.74,32.95 84.74,32.95 84.21,32.41 84.21,32.3 84.2,32.29 84.16,32.13 84.2,31.97 84.21,31.96 84.21,31.6 83.81,31.2 81.51,31.2 81.45,31.26 81.45,32.18 82.15,32.88 82.36,32.88 82.57,32.67 83.25,32.67 84.21,33.64 86.11,33.64 86.11,33.63 86.28,33.63 86.38,33.53 86.38,33.52 86.62,33.31 86.94,33.37 87.11,33.37 87.23,33.49 88.59,33.49 88.64,33.55 88.7,33.55 88.81,33.66 89.44,33.66 89.47,33.69 90.97,33.69
GND on BOTTOM (solid shape): 8.36,13.55 9.19,13.23 10.07,13.11 10.26,12.91 10.26,12.02 8.67,10.43 8.6,10.4 8.53,10.43 8.51,10.44 8.49,10.48 8.52,10.52 8.4,11.18 8.08,10.59 8.1,10.52 8.06,10.45 8.02,10.41 7.99,10.37 7.09,10.37 6.2,11.26 6.2,12.28 7.47,13.55
GND on BOTTOM (solid shape): 19.09,58.89 19.09,57.62 18.39,56.92 18.07,56.92 17.76,57.24 16.93,57.24 16.68,56.98 16.68,56.84 16.68,55.77 16.42,55.52 15.98,55.52 15.85,55.65 15.85,58 16.22,58.37 16.57,58.32 16.79,58.6 16.79,58.62 16.9,58.73 17.01,58.76 17.08,58.67 17.59,58.38 17.67,58.96 17.64,59.07 17.74,59.14 18.83,59.14
GND on BOTTOM (solid shape): 83.63,66.03 83.63,66.01 83.64,65.94 83.67,65.87 83.67,61.93 84.3,61.3 84.3,59.02 84.27,59 84.09,58.76 84.19,58.47 84.19,57.88 83.64,57.34 83.64,53.45 84.3,52.79 84.3,51.75 84.22,51.64 84.19,51.51 84.19,51.49 84.12,51.42 84.12,51.4 84.07,51.31 83.97,51.31 83.76,51.34 83.57,51.24 82.8,51.24 82.73,51.16 82.73,50.35 82.86,50.22 83.51,50.22 83.65,50.09 83.65,46 85.69,43.96 85.69,41.23 85.69,41.2 85.61,41.12 85.61,40.89 84.56,39.84 84.56,36.92 83.92,36.28 82.14,36.28 81.76,35.9 79.99,35.9 79.73,36.15 79.73,43.65 81.37,45.29 81.37,50.13 81.08,50.43 81.08,51.22 81.38,51.52 81.38,66 81.51,66.13 83.54,66.13
GND on BOTTOM (solid shape): 7.09,55.83 7.1,55.83 7.35,55.58 9.8,55.58 9.98,55.76 12.12,55.76 13.86,54.02 26.48,54.02 26.48,36.22 10.69,36.22 10.69,36.49 1.25,36.49 1.25,37.71 1.33,37.88 1.5,37.96 2.52,37.96 10.78,37.96 10.87,37.94 10.96,37.88 11.1,37.79 11.27,37.76 11.59,37.89 11.72,38.21 11.72,38.74 11.73,38.74 11.73,39.57 16.59,39.57 16.59,37.02 25.68,37.02 25.68,53.22 14.69,53.22 14.69,52.8 15.09,52.41 16.1,52.41 16.61,51.9 16.61,51.6 15.77,50.76 11.73,50.76 11.73,51.08 11.72,51.08 11.72,52.11 11.4,52.54 10.89,52.36 8.33,52.36 4.71,52.36 0.9,52.36 0.73,52.44 0.65,52.61 0.65,54.34 0.65,56.47 0.7,56.51 5.2,56.51 5.2,56.85 6.07,56.85
GND on BOTTOM (solid shape): outline of 201 points within 0.65,0.44 217.56,81.75
GND on IN1 (solid shape): 83.67,49.49 83.67,46.19 83.41,45.93 81.76,45.93 81.38,46.31 81.38,49.33 81.79,49.74 83.41,49.74
GND on IN1 (solid shape): 83.67,65.74 83.67,61.05 84.3,60.41 84.3,51.39 84.18,51.27 84.04,51.27 84.03,51.28 83.81,51.34 83.6,51.27 81.13,51.27 80.87,51.52 80.87,64.6 81.76,65.49 82.65,65.49 83.16,66 83.41,66
GND on IN1 (solid shape): 7.34,55.58 11.37,55.58 12.92,54.04 14.86,54.04 16.61,52.28 16.61,50.89 16.36,50.63 11.72,50.63 11.72,52.11 11.4,52.54 10.89,52.36 0.9,52.36 0.73,52.44 0.65,52.61 0.65,56.98 5.94,56.98
GND on IN1 (solid shape): 16.65,36.49 1.25,36.49 1.25,37.71 1.33,37.88 1.5,37.96 2.56,37.96 10.78,37.96 10.87,37.94 10.96,37.88 11.1,37.79 11.27,37.76 11.59,37.89 11.72,38.21 11.72,38.74 11.73,38.74 11.73,39.57 16.65,39.57
GND on IN1 (solid shape): outline of 279 points within 31.01,61.29 38.55,65.78
GND on IN1 (solid shape): outline of 311 points within 6.85,57.07 14.6,65.01
GND on IN1 (solid shape): outline of 187 points within 0.65,0.39 217.56,81.75
GND on IN2 (solid shape): 7.98,54.95 12.93,54.95 16,51.88 16.2,51.88 16.49,51.59 16.49,51.06 16.18,50.76 11.72,50.76 11.72,52.11 11.4,52.54 10.89,52.36 0.9,52.36 0.73,52.44 0.65,52.61 0.65,56.85 6.07,56.85
GND on IN2 (solid shape): 16.65,36.49 1.25,36.49 1.25,37.71 1.33,37.88 1.5,37.96 2.42,37.96 10.78,37.96 10.87,37.94 10.96,37.88 11.1,37.79 11.27,37.76 11.59,37.89 11.72,38.21 11.72,38.74 11.73,38.74 11.73,39.57 16.65,39.57
