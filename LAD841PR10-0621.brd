# Allegro board LAD841PR10-0621.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MEM_CONFIG0: length 5.6
  TOP w0.127: RH144.1 155.02,53.78 155.02,53.31 154.61,52.9 RH129.2 153.36,53.88 v2(153.36,54.04)
  BOTTOM w0.076: v2(153.36,54.04) 153.25,53.93 152.12,53.93 151.97,53.98 151.92,54.01 151.77,54.06 UCPU1.AP2
MEM_CONFIG1: length 10.7
  TOP w0.127: v2(153.27,54.62) 152.89,55 152.5,55 152.13,54.63 152.13,54.25 151.84,53.95 151.84,53.18 RH139.2 152.34,51.79 152.56,51.57 153.4,51.57 153.8,51.96 155.17,51.96 v3(155.55,52.34) RH150.1
  BOTTOM w0.127: v2(153.27,54.62) 152.81,54.16 152.17,54.16 UCPU1.AP1
MEM_CONFIG2: length 22.5
  TOP w0.127: v2(154.59,54.87) 154.59,54.87 155.27,54.87 RH149.1
  IN1 w0.081: v2(157.18,67.93) 157.18,67.48 157.95,66.7 157.95,65.01 157.75,64.8 157.4,64.8 155.95,63.35 155.95,55.75 155.07,54.87 154.59,54.87 v2(154.59,54.87)
  BOTTOM w0.076: v2(154.59,54.87) 154.36,55.1 152.64,55.1 152.4,54.87 152.19,54.87 151.94,54.62 151.34,54.62 150.93,54.22 UCPU1.AP3
  BOTTOM w0.127: RH145.2 156.49,68 157.1,68 v2(157.18,67.93)
MEM_CONFIG3: length 7.3
  TOP w0.127: RH146.2 RH151.1 155.37,56.75 v2(154.94,56.75)
  BOTTOM w0.076: UCPU1.AN3 150.53,54.88 150.9,55.25 152.32,55.25 152.51,55.44 154.34,55.44 154.46,55.56
  BOTTOM w0.127: v2(154.94,56.75) 154.94,56.13 v3(154.93,56.12) 154.61,55.8 154.61,55.71 154.46,55.56
MEM_CONFIG4: length 17.3
  TOP w0.127: RH152.1 v2(154.89,55.38)
  IN1 w0.081: v2(154.89,55.38) 155.75,56.24 155.75,63.44 157.48,65.18 v2(157.48,65.29)
  BOTTOM w0.076: UCPU1.AN1 151.99,55.08 152.38,55.08 152.58,55.27 154.78,55.27 v2(154.89,55.38)
  BOTTOM w0.127: RH147.2 158.22,66.02 v3(158.08,65.89) v2(157.48,65.29)
MEM_SMBCLK: length 11
  TOP w0.076: 150.28,64.47 149.68,64.47 v2(149.09,63.88)
  TOP w0.127: QC2.6 157.73,65.72 157.23,65.72 157.05,65.54 157.05,65.31 RC12.1 156.48,64.86 155.95,64.33 154.28,64.33 154.06,64.54 152.77,64.54 v3(152.71,64.47) 150.28,64.47
  BOTTOM w0.127: UCPU1.R7 148.74,64.22 v2(149.09,63.88)
MEM_SMBDATA: length 13.4
  TOP w0.076: v2(148.4,63.9) 148.82,63.48 152.37,63.48 152.61,63.72
  TOP w0.127: 152.61,63.72 153.13,64.24 154.05,64.24 154.18,64.11 155.26,64.11 155.52,63.84 RC14.1 155.78,63.84 156.28,64.34 156.92,64.34 157.18,64.6 158.62,64.6 159.52,63.71 QC2.3
  BOTTOM w0.127: UCPU1.R8 148.09,64.21 v2(148.4,63.9)
MIC2-VREFO: length 22.5
  TOP w0.203: 23.96,30.28 24.61,30.28 UA2.29
  TOP w0.254: 23.96,30.28 23.8,30.28 23.56,30.51 23.24,30.51 23.16,30.59 21.28,30.59 v3(20.93,30.25) 20.41,29.73 v2(20.41,29.47) ; v2(9.02,23.76) 8.59,23.33 RA28.1
  IN4 w0.254: v2(20.41,29.47) 20.05,29.12 20.05,25.32 18.49,23.76 v2(9.02,23.76)
  BOTTOM w0.203: v2(9.02,23.76) 8.74,23.48 RA27.1
MONO_IN: length 4.9
  TOP w0.127: v3(30.16,36.65) 29.65,36.14 CA34.2
  TOP w0.203: UA2.16 28.66,33.07 28.82,33.23 28.82,34.87 28.8,34.88 28.8,35.95 CA34.2
MPHYP_PWR_EN: length 44.6
  TOP w0.127: RH557.1 159.02,80.77 159.68,80.77 160.55,79.89 v3(160.55,79.18) 160.55,78.09 v2(158.78,76.31)
  IN1 w0.081: v2(158.78,76.31) 158.59,76.12 158.45,76.12 158.12,75.79 158.12,74.86 158.6,74.38 158.6,72.22 161.29,69.53 161.29,67.68 159.36,65.74 159.36,64.22 157.95,62.8 157.95,61.97 157.88,61.97 156.37,60.46 156.37,55.21 154.99,53.83 154.42,53.83 v2(154.41,53.84)
  IN3 w0.089: v2(146.31,55.69) 146.31,55.81 146.77,56.28 149.81,56.28 152.51,53.58 154.14,53.58 v2(154.41,53.84)
  BOTTOM w0.076: UCPU1.AM10 146.66,56.05 v2(146.31,55.69)
MSCLK: length 9.7
  BOTTOM w0.127: JDEG1.6 172.15,68.22 172.15,67.73 172.06,67.63 172.06,67.14 173.08,66.13 RE72.2 172.57,65.26 172.57,64.56 173.3,63.83 v3(173.31,63.83) 174.48,63.83 174.65,63.66 175.24,63.66 176.03,62.87 176.93,62.87 RE105.1
MSDATA: length 14.1
  TOP w0.127: RE104.1 RE85.1 171.37,61.98 v2(171.37,62.66)
  IN1 w0.081: v2(171.37,62.66) 171.19,62.85 171.19,63.72 171.56,64.09 171.75,64.09 173.05,65.39 173.05,66.89 v2(172.52,67.42)
  BOTTOM w0.127: v2(172.52,67.42) 172.52,67.21 RE75.2 173.97,66.46 v3(173.52,66.9) 173.52,67.05 172.65,67.92 172.65,68.22 JDEG1.7
MSM_N: length 62.9
  IN2 w0.089: v2(119.74,54.37) 119.54,54.37 119.26,54.1 119.26,52.95 118.91,52.6 118.91,51.54 114.8,47.43 113.94,47.43 113.34,46.82 113.34,42.43 111.12,40.22 104.67,40.22 103.57,39.11 103.57,36.93 102.23,35.59 102.08,35.59 100.2,33.71 98.62,33.71 98.3,34.04 95.45,34.04 94.83,33.42 94.83,31.92 94.06,31.15 94.06,28.88 94.16,28.78 94.16,25.97 94.69,25.44 94.69,25 94.49,24.8 93.47,24.8 92.66,25.61 89.7,25.61 88.94,24.85 v2(87.97,24.85)
  BOTTOM w0.076: v2(119.74,54.37) 120.12,54.75 UCPU1.AP56
  BOTTOM w0.127: v2(87.97,24.85) 87.46,24.34 v3(87.22,24.34) 83.08,24.34 PR1524.2
NB_MUTE#: length 34.5
  TOP w0.127: 32.18,15.78 32.18,14.58 31.11,13.51 24.92,13.51 24.53,13.89 20.81,13.89 18.77,15.93 18.77,17.2 v3(19.34,17.77) 20.04,18.47 RA57.1 ; 32.18,15.78 32.18,18.75 30.88,20.05 30.88,21.64 30.69,21.84 30.69,22.59 30.96,22.87 30.96,23.83 RA59.1 ; 32.18,15.78 32.33,15.93 v2(36.15,15.93)
  BOTTOM w0.127: v2(36.15,15.93) 36.45,16.23 UE4.20
NB_PSID: length 2.8
  TOP w0.127: PR108.2 28.4,73.32 v2(28.4,73.54)
  BOTTOM w0.127: JP100.3 27.46,73.79 27.71,73.54 v2(28.4,73.54)
NC_B4: length 11
  TOP w0.076: v2(35.69,56.4) 35.89,56.6 37.13,56.6 37.14,56.61 37.65,56.61 37.89,56.84 UT1.B4
  TOP w0.127: v1(33.08,58.89) 32.68,59.29 v2(32.66,59.29) 32.2,59.76 32.2,61.04 32.39,61.23 RT50.2
  IN2 w0.089: v2(32.66,59.29) 33.25,58.71 33.25,56.98 33.66,56.57 35.51,56.57 v2(35.69,56.4)
NC_B5: length 10.7
  TOP w0.076: 35.89,58.43 36.78,57.54 37.66,57.54 UT1.B5
  TOP w0.127: 35.89,58.43 35.31,59.01 33.58,59.01 32.45,60.14 32.45,60.8 33.02,61.37 RT48.2 33.17,61.79 33.37,61.99 33.37,63.06 v3(32.89,63.54)
NC_G2: length 12.1
  TOP w0.076: UT1.G2 39.98,55.7 39.98,55.21
  TOP w0.127: 39.98,55.21 40.07,55.12 40.07,54.48 40.79,53.76 40.79,52.13 40.96,51.96 40.96,50.02 40.63,49.68 40.27,49.68 38.08,47.49 38.08,46.99 37.91,46.82 v1(37.82,46.82) 37.66,46.66 RT49.2
NRB_BIT: length 3.5
  TOP w0.127: v2(148.08,54.38) 148.29,54.38 148.58,54.09 148.58,53.35 148.79,53.14 v3(148.84,53.14) 149.35,53.14 RC186.2
  BOTTOM w0.076: v2(148.08,54.38) 148.1,54.37 148.28,54.37 UCPU1.AR7
NTC_IA: length 2.8
  TOP w0.203: PU1000.15 72.17,53.36 72.55,52.99 72.55,52.98 73.19,52.98 73.86,52.31 PR1064.2
P_SYS: length 247
  TOP w0.127: v2(182.43,57.11) 182.86,57.54 UE5.A57 ; v2(64.26,47.46) 64.24,47.48 PR1083.1 ; v2(38.81,25.79) 38.83,25.79 39.32,26.29 40.03,26.29 40.48,26.73 PR319.1 41.97,26.82 43.22,28.07 43.22,31.37 44.32,32.47 44.32,33.86 46.36,35.9 v2(46.91,35.9)
  IN1 w0.081: v2(46.91,35.9) 48.07,37.05 48.07,41.47 49.3,42.71 49.3,44.4 50.05,45.15 50.79,45.15 52.73,47.09 52.73,49.45 53.17,49.89 61.6,49.89 64.04,47.46 v2(64.26,47.46)
  IN2 w0.089: v2(41.43,15.02) 41.78,15.37 50.63,15.37 51.53,16.27 54.26,16.27 54.86,15.68 65.06,15.68 65.58,15.16 94.73,15.16 95.68,16.11 99.55,16.11 100.94,14.72 108.13,14.72 109.04,15.63 111.13,15.63 111.74,15.02 115.49,15.02 116.97,13.55 126.04,13.55 128.11,15.62 130.03,15.62 132.39,13.26 172.84,13.26 174.7,15.12 174.7,21.29 175.65,22.25 175.65,36.9 176.4,37.65 176.54,37.65 178.03,39.14 178.03,40.33 178.34,40.64 179.08,40.64 179.54,41.1 180.44,41.1 182.04,42.71 182.04,48.37 183.07,49.4 183.07,51.38 184.84,53.14 184.84,55 183.78,56.05 183.78,56.99 183.36,57.41 182.74,57.41 v2(182.43,57.11)
  IN4 w0.081: v2(38.81,25.79) 38.81,24.84 38.38,24.41 38.38,20.23 41.43,17.18 v2(41.43,15.02)
  BOTTOM w0.127: v2(64.26,47.46) v3(65.09,47.46)
PANEL_BKEN_EC: length 176.7
  TOP w0.127: v2(177.75,20.61) 179.68,22.54 181.78,22.54 186.17,26.93 187.61,26.93 188.05,27.37 188.96,27.37 D72.3
  IN1 w0.089: v2(30.33,14.69) 30.78,15.15 31.72,15.15 31.97,14.89 38.6,14.89 38.97,15.26 38.97,15.67 39.5,16.2 41.94,16.2 42.99,15.16 49.5,15.16 50.58,16.24 54.45,16.24 54.78,15.92 57.63,15.92 58.85,17.14 59.78,17.14 60.16,16.75 66.51,16.75 66.51,16.76 67.52,16.76 69.41,18.64 86.52,18.64 87.01,18.15 90.21,18.15 91.8,16.56 93.92,16.56 94.57,17.22 101.03,17.22 102.44,15.81 108.11,15.81 108.82,16.52 110.95,16.52 111.67,15.81 115.65,15.81 116.59,14.87 125.98,14.87 127.48,16.37 131.24,16.37 133.43,14.18 156.38,14.18 159.51,17.31 165.7,17.31 166.41,16.6 174.07,16.6 177.75,20.28 v2(177.75,20.61)
  BOTTOM w0.127: v2(30.33,14.69) 30.33,14.74 29.67,15.4 29.67,16.9 30.29,17.53 UE4.4
PANEL_BKLEN: length 77.7
  TOP w0.127: D72.2 188.96,28.68 187.25,28.68 186.52,27.95 186.52,27.68 184.39,25.55 180.92,25.55 180.19,24.83 v3(179.93,24.83) v2(178.05,24.83)
  IN4 w0.089: v2(145.84,63.82) 146.61,63.05 153.56,63.05 154.6,64.1 156.4,64.1 156.95,63.55 158.11,63.55 158.47,63.19 160.23,63.19 161.15,62.28 161.15,57.9 159.61,56.36 159.61,52.84 164.46,47.99 165.71,47.99 166.2,47.5 166.2,46.78 167.55,45.42 168.05,45.42 168.99,44.48 168.99,43.41 169.6,42.8 169.6,40.19 170.07,39.73 170.07,38.5 171.91,36.66 171.91,31.78 172.34,31.35 172.34,30.16 175.77,26.73 175.77,25.66 176.59,24.84 178.03,24.84 v2(178.05,24.83)
  BOTTOM w0.127: v2(145.84,63.82) 145.49,64.18 UCPU1.R12
PBAT_PRES#: length 203.6
  TOP w0.127: v2(36.45,32.65) 37.01,32.09 PR326.1 ; v2(66.7,18.65) PR100.2 66.12,17.87 PRP100.1 67.16,17.33 66.78,16.95 PD100.3 ; v2(177.57,58) 177.6,58.02 178.66,58.02 UE5.A49
  IN1 w0.081: v2(177.57,58) 176.92,57.35 176.92,56.72 177.38,56.26 177.38,54.09 177.55,53.93 177.55,53.51 177.1,53.06 175.99,53.06 173.43,50.5 173.43,46.84 171.9,45.31 171.9,43.66 171.47,43.23 171.47,39.61 168.45,36.58 168.45,34.76 167.08,33.39 167.08,32.63 167.75,31.96 167.75,27.98 164.54,24.77 164.54,22.51 161.3,19.27 158.61,19.27 156.82,17.48 152.26,17.48 150.89,16.11 135.13,16.11 134.06,17.18 133.16,17.18 132.04,18.29 126.68,18.29 125.83,17.44 116.74,17.44 116.19,17.99 112.21,17.99 110.64,19.56 109.79,19.56 109.59,19.76 102.65,19.76 102.27,20.15 96.58,20.15 94.3,22.43 92.66,22.43 89.28,25.81 82.78,25.81 81.89,24.93 79.38,24.93 78.7,25.61 76.04,25.61 76.04,25.6 71.25,20.82 69.18,20.82 67.01,18.65 v2(66.7,18.65) 66.57,18.78 66.12,18.78 64.57,20.33 63.35,20.33 62.51,21.16 54.89,21.16 54.68,20.95 52.18,20.95 50.82,19.58 49.55,19.58 48.13,18.16 45.37,18.16 v2(45.19,18.34)
  IN4 w0.081: v2(36.45,32.65) 37.8,31.3 37.8,30.31 38.08,30.03 38.78,30.03 38.94,29.87 38.94,27.64 40.04,26.55 40.04,25.47 39.58,25.02 39.58,23.69 39.12,23.23 39.12,20.89 39.93,20.07 41.68,20.07 43.85,17.91 44.81,17.91 45.19,18.29 v2(45.19,18.34)
PBAT_SMBCLK: length 169.2
  TOP w0.127: PRP100.3 68.16,17.59 68.03,17.47 68.03,17.41 68.16,17.28 68.58,17.28 68.98,16.89 68.98,16.74 v2(69.24,16.48) 69.02,16.25 69.02,16.06 69.69,15.39 69.85,15.39 PD101.3 ; UE5.A56 182.36,57.82 182.36,57.63 181.91,57.18 181.91,56.22 v2(181.65,55.97)
  IN1 w0.081: 69.01,17.19 69.01,16.71 v2(69.24,16.48)
  IN1 w0.089: v2(181.65,55.97) 181.5,55.81 181.5,54.42 181.01,53.94 181.01,50.25 180.2,49.44 180.2,49.07 179.72,48.59 178.26,48.59 177.58,47.91 177.58,47.51 175.67,45.6 175.67,45.02 174.8,44.15 174.8,41.2 175,41 175,38.25 173.97,37.21 173.97,35.49 175.26,34.2 175.26,26.42 176.83,24.85 177.17,24.85 179.2,22.82 179.2,21.12 174.24,16.16 166.19,16.16 165.89,16.46 162.09,16.46 161.34,15.71 159.63,15.71 158.97,15.05 158.97,14.63 158.09,13.75 133.25,13.75 131.06,15.93 127.66,15.93 126.16,14.44 116.41,14.44 115.47,15.37 111.49,15.37 110.77,16.09 109,16.09 108.29,15.37 102.26,15.37 100.9,16.74 94.75,16.74 94.14,16.13 91.51,16.13 89.92,17.72 86.83,17.72 86.34,18.21 71.26,18.21 70.45,17.4 69.22,17.4 69.01,17.19
  BOTTOM w0.127: RE53.2 181.56,57.36 v4(181.56,56.7) 181.56,56.07 181.65,55.98 v2(181.65,55.97)
PBAT_SMBDAT: length 170
  TOP w0.127: PD101.2 69.85,15.11 69.61,15.11 68.76,15.96 68.76,16.17 68.46,16.47 v2(68.46,16.48) 68.65,16.67 68.65,16.85 68.47,17.03 68.06,17.03 67.78,17.31 67.78,17.47 67.66,17.6 PRP100.2 ; UE5.B59 182.11,58.67 182.11,59.08 v2(182.31,59.28)
  IN1 w0.081: v2(68.46,16.48) 68.8,16.82 68.8,17.09 68.79,17.1 68.79,17.27 68.84,17.32 68.84,17.33 68.85,17.34
  IN1 w0.089: v2(181.07,55.98) 181.28,55.76 181.28,54.51 180.79,54.03 180.79,50.34 179.99,49.53 179.99,49.16 179.63,48.81 178.17,48.81 177.36,48 177.36,47.6 175.45,45.69 175.45,45.11 174.59,44.24 174.59,41.11 174.79,40.91 174.79,38.34 173.75,37.3 173.75,35.4 175.04,34.11 175.04,26.33 176.74,24.63 177.08,24.63 178.98,22.73 178.98,21.21 174.15,16.38 166.28,16.38 165.98,16.68 162,16.68 161.25,15.93 159.54,15.93 158.76,15.14 158.76,14.72 158,13.97 133.34,13.97 131.15,16.15 127.57,16.15 126.07,14.65 116.5,14.65 115.56,15.59 111.58,15.59 110.86,16.3 108.91,16.3 108.2,15.59 102.35,15.59 100.99,16.96 94.66,16.96 94.05,16.35 91.6,16.35 90.01,17.93 86.92,17.93 86.43,18.42 71.17,18.42 70.36,17.61 69.13,17.61 68.85,17.34
  BOTTOM w0.127: v2(182.31,59.28) v3(181.91,58.88) 181.2,58.17 RE52.2 181.31,57.77 181.31,56.21 v2(181.07,55.98)
PBATT+_C: length 10.2
  TOP w0.127: v3(70.41,25.63) v2(70.41,24.85) 72.45,24.85 v3(73.1,25.5)
  TOP w0.508: PC102.2 70.59,19.77 71.22,20.41 v3(71.22,20.79) 71.22,21.82 70.28,22.76 70.28,24.72 v2(70.41,24.85)
PBTN_SW#: length 107
  TOP w0.127: RE33.2 CE21.1 189.08,50.5 191.75,50.5 192.48,49.77 v3(195.63,49.77) v2(197.16,49.77) ; SW2.4 SW2.2 v2(191.75,79.01)
  IN4 w0.081: v2(191.75,79.01) 191.75,77.08 193.13,75.7 196.63,75.7 ; v2(206.25,17.69) 206.25,20.3 202.26,24.29 202.26,30.44 v2(201.81,30.89)
  IN4 w0.089: 196.63,75.7 198.26,74.08 198.26,69.1 196.3,67.14 195.33,67.14 194.51,66.33 194.51,65.92 193.57,64.98 192.24,64.98 191.76,64.5 191.76,61.09 192.06,60.79 192.62,60.79 192.93,61.09 192.93,61.33 193.29,61.69 193.29,61.72 193.37,61.8 193.37,62.15 193.53,62.31 193.95,62.31 194.18,62.08 194.18,61.68 193.97,61.47 193.67,61.47 193.35,61.15 193.35,60.56 192.68,59.89 192.68,59.57 192.44,59.33 192.44,57.43 194.76,55.11 194.76,52.43 197.14,50.04 197.14,49.78 ; 197.14,49.78 196.55,49.18 196.55,37.27 196.72,37.09 197.59,37.09 199.44,35.24 199.77,35.24 200.91,34.1 200.91,31.81 201.81,30.92 v2(201.81,30.89) ; 197.14,49.78 v2(197.16,49.77)
  BOTTOM w0.127: v2(206.25,17.69) 205.72,17.15 204.78,17.15 204.06,16.44 202.67,16.44 202.47,16.65 200.53,16.65 200.01,16.12 200.01,15.54 JIO1.35 ; v2(201.81,30.89) 200.76,30.89 JAPS1.11
PCH_ALW_ON: length 48.5
  TOP w0.127: v2(189.92,41.13) 189.92,39.8 186.57,36.46 183.52,36.46 183.1,36.04 R1443.1 ; UE5.A34 177.16,66.52 176.84,66.52 v2(176.38,66.98)
  IN4 w0.081: 187.29,56.93 187.29,56.28 185.68,54.67 185.68,53.27 189.08,49.87 189.08,49.38 189.58,48.87 190.08,48.87 191.04,47.91 191.04,44.39 189.92,43.27 v2(189.92,41.13)
  IN4 w0.089: 187.29,56.93 186.3,57.93 182.15,57.93 181.29,58.78 181.29,59.25 180.66,59.89 178.66,59.89 178.18,60.37 178.18,62.42 177.27,63.33 177.27,66.1 176.38,66.98 v2(176.38,66.98)
PCH_BATLOW#: length 7.1
  TOP w0.127: RC72.1 147.02,48.09 146.4,48.72 v1(146.4,48.85) 145.95,49.3 145.95,51.1 145.28,51.78 145.15,51.78 144.43,52.49 v2(144.38,52.49)
  BOTTOM w0.076: UCPU1.AU13 144.72,52.8 144.41,52.49 v2(144.38,52.49)
PCH_DPWROK: length 3.7
  TOP w0.127: UE5.A36 176.6,65.52 v2(176.47,65.4) 176.47,65.4 176.14,65.07 175.61,65.07 175.39,65.3 175.39,66.11 v3(175.49,66.2)
  BOTTOM w0.127: RC221.2 176.56,65.31 v2(176.47,65.4)
PCH_DPWROK_R: length 71.2
  TOP w0.127: v2(144.81,43.93) 144.22,44.51 v3(144.09,44.51) 143.1,43.52 RC220.1
  IN3 w0.089: v2(144.81,43.93) 145.21,43.93 145.83,44.55 146.88,44.55 148.29,45.95 148.29,47.39 149.32,48.42 153.42,48.42 154.79,49.79 157.42,49.79 158.98,51.35 160.31,51.35 161.04,50.62 164.28,50.62 166.02,52.37 166.02,56.76 166.51,57.25 170.11,57.25 171.26,56.11 173.3,56.11 174.41,57.23 174.41,58.31 174.22,58.5 174.22,61.77 174.54,62.09 178.07,62.09 178.61,61.55 179.57,61.55 180.81,62.79 180.81,64.12 180.1,64.83 176.35,64.83 175.9,65.28 v2(175.9,65.49)
  BOTTOM w0.127: v2(175.9,65.49) 175.9,65.28 176.27,64.91 176.58,64.91 177.09,64.4 RC221.1 ; UCPU1.BB20 141.3,49.53 141.3,48.7 141.48,48.52 141.48,48.05 143.61,45.91 CC266.1 144.12,44.92 144.22,44.92 RC215.1 144.81,44.33 v2(144.81,43.93)
PCH_JTAG_TCLK: length 74.1
  TOP w0.127: v2(73.84,71.48) 73.28,70.93 71.91,70.93 71.38,70.39 67.1,70.39 66.67,70.82 66.67,71.11 66.32,71.46 65.63,71.46 65.1,72 JXDP1.55 ; v2(95.05,76.97) 95.05,78.36 96.79,80.1 118.79,80.1 v3(118.87,80.02) 119.3,80.02 120.37,78.95 120.37,78.16 RC86.2 118.95,76.74 118.95,76.16 119.18,75.94 v2(119.18,75.65)
  BOTTOM w0.076: UCPU1.B56 120.07,71.8 120.07,71.86 120,71.97 120,72.09 119.94,72.21 119.94,72.47 120.13,72.65 120.13,73.6 119.39,74.33 119.39,75.46 119.18,75.68 v2(119.18,75.65)
  BOTTOM w0.127: v2(73.84,71.48) 74.61,72.26 79.93,72.26 80.29,71.9 85,71.9 86.36,70.53 88.67,70.53 89.65,71.52 89.65,73.27 91.02,74.63 93.63,74.63 95.05,76.05 v2(95.05,76.97)
PCH_PCIE_WAKE#: length 54.5
  TOP w0.127: v2(145.97,46.14) 145.54,45.7 RC67.2 ; UE5.B46 178.01,61.77 178.6,61.77 178.75,61.62 179.36,61.62 179.58,61.84 179.58,62.15 v2(179.57,62.16)
  IN3 w0.089: v2(145.97,46.14) 146.18,46.14 147.12,47.08 147.12,47.56 148.47,48.91 150.84,48.91 152.63,50.69 157.54,50.69 158.42,51.57 160.4,51.57 161.13,50.84 164.19,50.84 165.81,52.46 165.81,56.85 166.85,57.89 166.85,58.96 167.39,59.5 170.68,59.5 171.58,58.6 172.61,58.6 173.83,59.81 173.83,61.71 174.42,62.31 178.16,62.31 178.7,61.77 179.28,61.77 179.57,62.06 v2(179.57,62.16)
  BOTTOM w0.076: UCPU1.BB15 143.47,49.58 143.47,49.19 144.03,48.62 144.25,48.62 144.38,48.49 144.38,47.5 144.65,47.23
  BOTTOM w0.127: v2(145.97,46.14) 145.53,46.14 144.97,46.7 v3(144.97,46.91) 144.65,47.23
PCH_PLTRST#: length 27.6
  TOP w0.127: RC85.2 161.32,58.38 v2(160.15,58.38) ; RC85.2 161.14,59.06 UC7.1 ; RC85.2 161.79,58.85 161.79,59.77 ; RC226.2 161.93,63.79 162.94,62.77 162.94,61.3 161.79,60.15 161.79,59.77 ; 161.79,59.77 UC7.2
  IN3 w0.089: v2(160.15,58.38) 160.15,57.9 159.33,57.08 158.29,57.08 154.56,53.35 152.43,53.35 149.74,56.05 146.97,56.05 146.71,55.79 146.71,55.46 v2(146.26,55.01)
  BOTTOM w0.076: v2(146.26,55.01) 146.65,55.4 UCPU1.AN10
PCH_PLTRST#_EC: length 363.6
  TOP w0.127: R104.1 41.96,52.46 v1(41.96,51.61) 41.96,51.05 41.25,50.34 41.25,49.5 v2(40.9,49.15) ; UE5.B30 180.61,67.33 180.72,67.22 v2(180.72,67.2) ; U15.17 188.64,43.57 v2(189.08,43.14) ; 162.44,61.68 UC7.4 ; 162.44,61.68 162.44,62.34 RC226.1 RC65.1 ; 162.44,61.68 162.44,61.45 161.52,60.54 160.76,60.54 v2(160.53,60.31) ; v2(182.25,70.06) 182.22,70.09 RE54.2
  IN1 w0.081: v2(38.81,40.55) 38.81,42.5 40.39,44.08 40.39,48.64 40.9,49.15 v2(40.9,49.15)
  IN3 w0.089: v2(160.53,60.31) 161.57,60.31 162.71,61.45 162.71,62.54 163.78,63.6 167.85,63.6 169.21,64.97 172.25,64.97 172.59,65.31 172.59,66.15 176.86,70.43 178.98,70.43 179.38,70.82 181.48,70.82 v2(182.25,70.06)
  IN4 w0.081: v2(160.53,60.31) 160.41,60.43 157.49,60.43 156.88,59.81 156.88,58.87 157.17,58.58 157.47,58.58 158.29,57.76 158.29,57.68 158.98,56.99 158.98,52.55 166.48,45.05 166.48,41.48 166.68,41.28 166.68,39.23 167.99,37.91 167.99,34.95 166.94,33.9 166.94,28.91 165.73,27.71 165.73,23.18 161.2,18.65 147.37,18.65 146.98,19.04 145.66,19.04 145.17,18.55 123.35,18.55 123.24,18.67 101.88,18.67 99.07,21.48 97.24,21.48 96.07,22.66 96.07,24.84 95.97,24.94 95.97,27.35 92.24,31.08 91.86,31.08 91.59,31.35 85.77,31.35 83.8,29.38 81.89,29.38 81.57,29.69 79.27,29.69 75.68,26.09 75.15,26.09 67.09,18.03 63.75,18.03 62.9,17.18 59.04,17.18 55.95,20.27 54.7,20.27 52.92,18.49 49.63,18.49 48.82,17.69 46.41,17.69 45.34,18.75 43.59,18.75 41.85,20.49 41.51,20.49 41.04,20.97 41.04,21.78 40.02,22.8 40.02,24.13 41.06,25.18 41.06,26.2 39.39,27.87 39.39,31.21 37.67,32.93 37.67,34.11 35.93,35.85 35.93,37.91 38.57,40.55 v2(38.81,40.55)
  IN4 w0.089: v2(182.25,70.06) 182.3,70.06 182.78,69.59 182.78,69.17 182.45,68.84 182.19,68.84 180.72,67.37 v2(180.72,67.2) 180.72,67.01 181.31,66.43 181.31,65.82 185.27,61.85 186.72,61.85 187.07,61.5 187.07,60.61 187.22,60.46 187.22,58.81 188.12,57.92 188.8,57.92 189.58,57.14 189.58,53.22 190.48,52.32 190.61,52.32 193.03,49.9 193.27,49.9 193.69,49.48 193.69,48.38 v2(193.04,47.73) 194.64,46.14 194.64,35.84 196.44,34.04 196.44,26.35 198.2,24.6 200.38,24.6 v2(200.51,24.72)
  BOTTOM w0.127: v2(200.51,24.72) 200.02,24.23 200.02,20.38 199.49,19.86 199.49,19.2 199.11,18.82 JIO1.38 ; JNGFF1.44 44,47.32 42.36,48.97 41.08,48.97 v2(40.9,49.15) ; JNGFF2.50 175.6,35.55 176.84,35.55 176.98,35.41 178.91,35.41 181.51,38.01 187.15,38.01 187.45,37.7 190.07,37.7 190.38,38.01 190.38,39.1 189.68,39.79 189.68,40.73 189.08,41.33 v2(189.08,43.14) 189.42,43.48 190.23,43.48 192.47,45.72 192.47,47.16 v2(193.04,47.73) ; JLPDE1.8 183.15,70.84 182.37,70.06 v2(182.25,70.06)
PCH_POPIRCOMP: length 2.6
  TOP w0.305: RC89.1 142.22,50.91 142.57,51.27 v2(142.57,52.49)
  BOTTOM w0.254: UCPU1.AU16 142.99,52.8 v2(142.57,52.49)
PCH_PWR_EN: length 5
  TOP w0.127: U717.3 180.08,34.13 R1187.2 R1444.2 R1443.2 v3(184.07,35.12)
PCH_PWROK: length 96.9
  TOP w0.254: v2(63.02,50.96) 63.07,51.01 PR1027.1 ; v2(141.16,47.39) 141.16,48.23 140.54,48.85 140.11,48.85 139.07,47.81 137.77,47.81 137.39,47.43 137.39,41.51 136.22,40.34 115.11,40.34 110.39,45.07 v3(109.32,45.07) 104.88,45.07 104.33,44.52 100.04,44.52 v2(99.44,43.93)
  IN3 w0.203: v2(63.02,50.96) 63.25,50.96 65,49.21 65,47.83 66.39,46.44 68.5,46.44 71.02,43.93 83.92,43.93 84.48,44.48 85.5,44.48 86.06,43.93 96.34,43.93 96.61,43.66 99.17,43.66 v2(99.44,43.93)
  BOTTOM w0.076: v2(141.16,47.39) 141.07,47.48 141.07,49.31 140.87,49.51 140.87,50.05 UCPU1.BA20
PCH_RSMRST#: length 180.9
  TOP w0.127: v2(70.9,78.09) 71.02,78.09 71.6,77.5 RC124.1 ; v2(144.86,43.32) 144.45,42.91 RC75.2 ; UE5.A45 176.79,61.02 176.68,60.92 176.68,60.79 176.32,60.43 176.07,60.43 v2(175.76,60.13)
  IN3 w0.089: v2(171.76,72.5) 171.37,72.88 171.37,76.58 169.54,78.42 155.64,78.42 155.54,78.52 151.99,78.52 151.13,79.37 128.99,79.37 128.91,79.28 92.81,79.28 90.01,76.48 84.05,76.48 83.54,75.97 80.37,75.97 79.31,77.03 76.97,77.03 75.97,78.03 73.4,78.03 73.18,78.25 72.49,78.25 72.33,78.09 v2(70.9,78.09) ; v2(175.76,60.13) 175.15,59.51 175.15,56.33 174.48,55.66 171.09,55.66 169.94,56.82 166.69,56.82 166.45,56.58 166.45,52.19 164.44,50.18 158.42,50.18 157.6,49.36 155.71,49.36 154.56,48.21 149.41,48.21 148.5,47.3 148.5,45.86 146.97,44.33 145.92,44.33 144.91,43.32 v2(144.86,43.32)
  IN4 w0.081: v2(175.76,60.13) 175.76,60.17 174.61,61.31 174.61,61.58 173.44,62.75 173.44,64.36 173.35,64.45 173.35,66.31 173.81,66.77 173.81,68.11 173.18,68.74 173.18,71.44 172.12,72.5 v2(171.76,72.5)
  BOTTOM w0.076: RC215.2 144.12,45.93 143.89,45.93 142.11,47.71 142.11,49.79 142.17,49.91 142.17,50.05 142.1,50.28 142.1,50.4 142.17,50.61 142.27,50.72 142.38,50.83 UCPU1.AY17
  BOTTOM w0.127: v2(144.86,43.32) 145.24,43.7 145.24,44.81 RC215.2
PCH_RTCRST#: length 96.7
  TOP w0.127: v2(179.14,41.5) 179.53,41.11 179.82,41.11 180.24,40.7 180.24,40.49 182.62,38.11 186.18,38.11 187.13,39.06 188.3,39.06 189.38,40.15 189.38,41.36 189.77,41.74 190.14,41.74 190.58,41.31 190.58,33 191.45,32.13 199.3,32.13 v3(199.34,32.09) 199.75,32.09 v2(199.98,31.86) ; CC25.1 148.44,45.81 RC57.1 149.06,45.42 149.54,44.94 149.54,44.09 148.95,43.49 CMOS1.1 149.21,43.37 149.79,42.78 151.87,42.78 152.27,42.38 153.57,42.38 154.57,41.39 v2(155.93,41.39)
  IN4 w0.081: v2(142.6,55.64) 143.1,56.14 145.52,56.14 145.83,55.83 145.83,52.96 146.09,52.7 146.26,52.7 146.52,52.45 146.52,51.94 151.96,46.5 152.72,46.5 153.2,46.02 154.06,46.02 154.62,45.47 154.62,44.71 154.36,44.46 154.36,43.37 156,41.74 156,41.45 v2(155.93,41.39)
  BOTTOM w0.076: UCPU1.AM16 v2(142.6,55.64)
  BOTTOM w0.127: v2(179.14,41.5) 179.14,40.96 178.83,40.65 178.1,40.65 176.86,41.89 174.75,41.89 171.87,39.01 167.27,39.01 165.39,40.89 159.57,40.89 159.45,40.78 156.54,40.78 v2(155.93,41.39) ; JAPS1.9 200,31.89 v2(199.98,31.86)
PCH_RTCX1: length 23.1
  TOP w0.127: RC54.2 151.54,47.71 v2(151.8,47.44) 152.36,47.44 152.63,47.18 152.63,46.44 CC23.1 152.88,45.17 YC2.1 153.21,44.28 v3(154.18,43.31)
  IN1 w0.089: v2(151.8,47.44) 149.95,47.44 147.42,49.97 146.22,49.97 145.26,50.94 143.46,50.94 142.15,52.25 142.15,55.18 v2(141.68,55.64)
  BOTTOM w0.127: UCPU1.AM18 141.73,55.64 v2(141.68,55.64)
PCH_RTCX2: length 16.6
  TOP w0.127: RC296.1 150.47,47.08 RC54.1 149.61,47.48 v2(149.25,47.48)
  IN1 w0.081: v2(140.77,55.69) 140.73,55.69 140.34,55.3 140.34,52.94 141.22,52.05 141.68,52.05 143.27,50.47 145.06,50.47 146.07,49.46 147.27,49.46 v2(149.25,47.48)
  BOTTOM w0.127: UCPU1.AM20 140.87,55.69 v2(140.77,55.69)
PCH_RTCX2_R: length 8.9
  TOP w0.127: RC296.2 151.23,46.67 CC26.1 151.23,45.13 YC2.2 151.37,43.29 152.08,43.29 152.48,42.89 153.78,42.89 154.75,41.92 v3(155.31,41.92)
PCH_RTD3_CIO_PWR_EN: length 8.2
  BOTTOM w0.127: RC248.1 155.65,70.95 153.85,69.15 153.85,68.77 v3(153.57,68.49) 152.25,67.17 149.93,67.17 UCPU1.H5
PCH_SMB_ALERT#: length 10.1
  TOP w0.076: v2(147.14,64.99) 147.71,64.42 149.3,64.42 149.77,64.9 150.26,64.9 150.28,64.87 150.3,64.87
  TOP w0.127: RC23.1 154.94,65.74 154.07,64.87 150.3,64.87
  BOTTOM w0.127: v2(147.14,64.99) 146.79,64.64 UCPU1.R10
PCH_SPI_CLK: length 62.6
  IN1 w0.081: v2(197.39,76.8) 197.11,76.8 196.54,77.38 189.48,77.38 186.95,74.85 183.28,74.85 183.14,75 181.42,75 179.8,73.38 175.38,73.38 174.07,72.07 171.86,72.07 167.91,68.12 167.91,65.34 164.39,61.82 164.29,61.82 163.9,61.43 163.9,60.6 158.41,55.11 158.41,53.56 v2(157.78,52.94)
  BOTTOM w0.089: 153.94,51.97 153.52,51.97 153.06,52.43 151.4,52.43 UCPU1.AV2
  BOTTOM w0.127: 153.94,51.97 154.44,51.97 154.98,52.52 154.98,52.83 155.29,53.13 157.59,53.13 v2(157.78,52.94) ; JSPI1.8 197.34,76.86 v2(197.39,76.8) 197.39,75.79 RC60.1
PCH_SPI_CLK_R: length 68.4
  IN2 w0.089: v2(199.93,44.8) 198.85,45.87 198.85,50.47 203.01,54.63 203.01,59.85 202.52,60.35 202.52,61.67 200.01,64.17 200.01,67.81 200.31,68.11 200.31,70.65 199.85,71.11 197.99,71.11 v2(197.29,71.81)
  IN3 w0.089: v2(199.93,44.8) 199.55,45.18 190.93,45.18 189.74,43.99 188.42,43.99 187.85,44.56 184.38,44.56 181.37,47.56 180.12,47.56 180.05,47.49 178.69,47.49 178.51,47.67 178.51,48.38 179.39,49.26 v2(179.4,49.26)
  BOTTOM w0.127: JSPI1.7 197.84,77.21 197.92,77.12 197.92,76.07 197.99,76 197.99,75.35 RC60.2 197.46,73.8 197.14,73.48 v3(197.14,72.88) 197.14,71.96 v2(197.29,71.81) ; v2(179.4,49.26) 178.42,49.26 178.31,49.16 177.71,49.16 177.48,48.93 177.48,48.37 177.32,48.21 RP5.7 RP5.6
PCH_SPI_CLK_TPM: length 14.8
  TOP w0.127: C135.1 190.25,44.66 190.05,44.46 v2(189.03,44.46) 188.91,44.58 188.21,44.58 U15.19
  IN3 w0.089: v2(189.03,44.46) 188.61,44.46 187.32,45.75 184.07,45.75 181.76,48.06 179.02,48.06 v2(178.91,47.96)
  BOTTOM w0.127: RP5.3 178.67,47.71 v2(178.91,47.96)
PCH_SPI_CS0#: length 61.5
  IN1 w0.081: v2(162.48,57.84) 163.19,57.84 163.86,58.51 163.86,58.93 166.81,61.89 166.81,63.42 168.65,65.26 168.65,66.77 168.97,67.09 169.26,67.09 169.79,67.62 169.79,68.26 173.19,71.66 176.53,71.66 177.79,72.92 180.15,72.92 180.84,73.61 181.88,73.61 182.24,73.97 186.66,73.97 187.61,74.92 189.96,74.92 192,76.96 195.98,76.96 v2(196.34,76.6)
  BOTTOM w0.089: 153.89,52.2 153.55,52.2 153.14,52.61 151.09,52.61 UCPU1.AU3
  BOTTOM w0.127: 153.89,52.2 154.35,52.2 154.76,52.61 154.76,52.92 155.24,53.39 157.99,53.39 158.65,54.05 158.65,55.49 161.01,57.84 v1(161.35,57.84) v2(162.48,57.84) ; JSPI1.10 v2(196.34,76.6) 196.22,76.47 RC58.1
PCH_SPI_CS0#_R: length 55.3
  IN2 w0.089: v2(199.6,45.78) 199.93,46.11 199.93,50.62 203.66,54.35 203.66,60.12 203.22,60.56 203.22,63.85 202.16,64.91 202.16,66.08 201.33,66.9 201.33,71.68 199.7,73.31 197.17,73.31 v2(196.35,74.12)
  IN3 w0.089: v2(189.03,47.12) 189.73,46.42 196.27,46.42 197.09,45.61 199.42,45.61 v2(199.6,45.78)
  BOTTOM w0.127: JSPI1.9 196.84,75.43 RC58.2 196.22,74.26 v2(196.35,74.12) ; v2(189.03,47.12) 187.78,47.12 186.61,48.3 185.14,48.3 185.01,48.17 U18.1
PCH_SPI_CS2#: length 62.7
  TOP w0.127: RC230.2 185.85,40.06 187.42,40.06 188.28,40.92 188.28,42.75 187.59,43.43 187.59,44.75 187.92,45.08 U15.20 189.19,45.08 v2(189.25,45.01) 189.37,45.13 190.03,45.13 190.17,45.27 192.41,45.27 RH127.1
  IN3 w0.089: v2(179.91,50.07) 179.91,49.29 180.67,48.53 186.2,48.53 188.57,46.15 188.57,45.38 188.95,45.01 v2(189.25,45.01)
  BOTTOM w0.089: 153.93,52.41 153.64,52.41 153.24,52.82 152.19,52.82 UCPU1.AU1
  BOTTOM w0.127: v2(179.91,50.07) 179.53,49.69 178.39,49.69 178.11,49.42 177.35,49.42 177.3,49.37 176.3,49.37 175.54,50.12 175.54,50.96 174.7,51.8 172.76,51.8 170.7,53.85 167.49,53.85 167.1,54.24 167.1,55.46 164.72,57.85 163.63,57.85 163.22,58.26 161.01,58.26 158.19,55.44 v3(158.19,54.77) 158.19,53.95 157.97,53.73 155.27,53.73 154.55,53 154.55,52.69 154.26,52.41 153.93,52.41
PCH_SPI_DO2_XDP: length 112.6
  TOP w0.127: JXDP1.60 64.1,66.22 64.32,66 65.48,66 65.96,65.52 v2(66.29,65.52)
  IN1 w0.089: v2(66.29,65.52) 66.29,65.41 66.75,64.96 66.75,64.65 67.48,63.93 70.57,63.93 71.72,65.07 78.27,65.07 79.4,66.2 79.97,66.2 80.21,65.96 82.49,65.96 83.84,67.32 99.06,67.32 100.4,65.98 107.33,65.98 107.98,66.63 109.48,66.63 109.78,66.93 111.27,66.93 112.12,67.78 113.47,67.78 113.78,67.47 117.32,67.47 117.45,67.6 118.14,67.6 118.36,67.37 118.36,66.94 118.64,66.66 119.15,66.66 120.35,65.46 123.08,65.46 123.82,66.2 123.82,67.27 124.07,67.52 134.44,67.52 134.72,67.24 134.72,66.94 135.05,66.61 136.27,66.61 137.86,65.02 137.86,60.81 139.96,58.7 143.95,58.7 144.18,58.48 148.5,58.48 149.51,57.47 149.51,56.35 152.96,52.89 157.07,52.89 v2(157.61,52.35)
  BOTTOM w0.127: RC11.1 157.2,51.65 157.61,52.05 v2(157.61,52.35)
PCH_SPI_DO_XDP: length 124.6
  TOP w0.127: RC128.1 RC133.2 63.98,77.48 63.66,77.8 62.92,77.8 62.59,77.48 62.59,75.43 62.38,75.22 62.38,71.69 63.74,70.33 63.74,66.22 64.22,65.74 65.38,65.74 66.19,64.93 v2(66.19,64.93)
  IN1 w0.081: v2(157.01,52.35) 156.68,52.68 152.87,52.68 149.29,56.26 149.29,57.37 149.29,57.38
  IN1 w0.089: v2(66.19,64.93) 66.19,64.75 67.23,63.71 70.66,63.71 71.81,64.86 78.69,64.86 79.48,64.07 79.93,64.07 81.61,65.74 82.58,65.74 83.93,67.1 98.97,67.1 100.31,65.77 107.42,65.77 108.07,66.42 109.57,66.42 109.87,66.72 111.36,66.72 112.21,67.56 113.38,67.56 113.69,67.25 117.2,67.25 118.05,66.4 119.1,66.4 120.27,65.24 125.76,65.24 127.79,67.27 133.4,67.27 134.42,66.25 136.09,66.25 137.64,64.7 137.64,60.72 139.88,58.49 143.86,58.49 144.09,58.26 148.41,58.26 149.29,57.38
  BOTTOM w0.127: v2(157.01,52.35) 156.83,52.54 RC10.1
PCH_SPI_IO2: length 63.8
  IN1 w0.081: v2(159.56,50.71) 159.56,54.9 161.68,57.02 164.57,57.02 165.85,58.31 165.85,60.26 167.23,61.64 167.23,63.24 170.33,66.35 170.33,67.74 171.86,69.26 172.58,69.26 174.56,71.24 176.7,71.24 177.97,72.51 180.33,72.51 181.02,73.19 182.06,73.19 182.41,73.55 188.16,73.55 188.43,73.82 192.67,73.82 v2(195.41,76.56)
  BOTTOM w0.076: 152.45,51.14 151.98,51.14 151.49,51.63 UCPU1.AW2
  BOTTOM w0.127: 152.45,51.14 152.86,51.14 153.06,50.94 154.89,50.94 RC11.2 ; v2(159.56,50.71) 159.08,51.19 v3(158.64,51.19) 156.06,51.19 RC11.2 ; JSPI1.12 195.34,77.01 195.41,76.94 v2(195.41,76.56) 195.41,75.93 RC61.1 ; RC11.2 RH59.2
PCH_SPI_IO2_R: length 67.3
  IN2 w0.089: v2(199.52,46.37) 199.67,46.52 199.67,50.68 203.44,54.45 203.44,60.03 203,60.47 203,63.76 201.94,64.82 201.94,65.99 201.12,66.81 201.12,70.45 200.03,71.54 198.45,71.54 196.9,73.09 196.67,73.09 v2(195.63,74.13)
  BOTTOM w0.127: v2(199.52,46.37) 199.69,46.53 199.69,47.3 198.27,48.72 198.27,49.83 197.52,50.58 196.99,50.58 196.24,49.83 v3(193.73,49.83) 193.23,49.83 191.65,48.25 191.65,47.07 191,46.42 188.86,46.42 187.01,44.56 184.03,44.56 183.56,44.09 177.72,44.09 177.56,44.25 177.56,44.79 177.43,44.92 RP6.6 ; v2(195.63,74.13) 195.2,74.56 RC61.2 195.68,75.29 195.68,76.04 195.84,76.19 JSPI1.11
PCH_SPI_IO3: length 92.8
  IN1 w0.081: v2(194.29,76.25) 193.75,75.71 191.05,75.71 190.05,74.71 187.7,74.71 186.74,73.76 182.32,73.76 181.97,73.4 180.93,73.4 180.24,72.71 177.88,72.71 176.61,71.45 173.28,71.45 170.13,68.3 170.13,67.37 169.5,66.74 169.5,65.8 167.02,63.33 167.02,61.8 164.06,58.84 164.06,58.42 162.87,57.23 161.6,57.23 158.85,54.48 158.85,52.73 157.66,51.54 155.84,51.54 154.86,50.56 153.57,50.56 v2(153.24,50.22)
  BOTTOM w0.076: 152.58,50.55 152.53,50.51 151.99,50.51 151.84,50.66 151.4,50.66 151.18,50.88 151.18,51.02 150.91,51.29 150.24,51.29 149.96,51.57 149.96,52.04 150.22,52.29 150.22,52.84 UCPU1.AU4
  BOTTOM w0.127: RC62.1 194.18,76.14 v2(194.29,76.25) 194.34,76.29 JSPI1.14 ; RH56.2 RH58.2 175.31,44.2 174.48,43.37 173.83,43.37 v3(172.79,44.41) 171.81,45.38 169.23,45.38 169.02,45.17 162.81,45.17 162.49,44.85 159.75,44.85 159.08,45.52 159.08,47.51 159.66,48.1 159.66,49.11 158.74,50.03 158,50.03 157.77,49.8 157.04,49.8 156.58,50.26 155.29,50.26 154.99,50.55 153.57,50.55 v2(153.24,50.22) 152.91,50.55 152.58,50.55
PCH_SPI_IO3_R: length 66.3
  IN2 w0.089: v2(195.88,72.26) 197.43,72.26 198.36,71.33 199.94,71.33 200.9,70.36 200.9,64.96 202.73,63.13 202.73,60.44 203.23,59.94 203.23,54.54 199.26,50.58 v2(199.26,46.89)
  BOTTOM w0.127: v2(199.26,46.89) 199.26,47.03 198.02,48.27 198.02,49.52 197.34,50.21 196.98,50.21 195.85,49.07 v3(195.62,49.07) 192.83,49.07 191.91,48.15 191.91,46.97 191.11,46.16 188.97,46.16 187.12,44.31 184.13,44.31 183.66,43.84 177.61,43.84 177.3,44.15 177.3,44.34 177.23,44.42 RP6.5 ; JSPI1.13 194.84,76.18 194.67,76.01 194.67,75.17 RC62.2 194.18,73.95 v2(195.88,72.26)
PCH_SPI_SI: length 87.5
  IN1 w0.081: v2(153.95,51.52) 154.37,51.94 157.76,51.94 158.64,52.83 158.64,55.05 165.21,61.61 165.21,62.35 168.12,65.26 168.12,66.53 168.96,67.38 169.25,67.38 169.58,67.71 169.58,68.35 173.1,71.87 174.15,71.87 175.47,73.18 179.89,73.18 181.49,74.78 183.06,74.78 183.19,74.64 187.04,74.64 187.52,75.13 189.88,75.13 191.92,77.17 196.41,77.17 197.17,76.41 197.76,76.41 198.03,76.68 198.62,76.68 199.21,76.09 199.21,75.33 199.07,75.19 199.07,72.77 199.3,72.55 199.3,70.46 v2(199.7,70.06)
  BOTTOM w0.076: 151.85,51.82 151.77,51.9 151,51.9 150.7,52.2 UCPU1.AV3
  BOTTOM w0.127: 151.85,51.82 152.25,51.82 152.48,51.6 153.87,51.6 v2(153.95,51.52) 154.29,51.52 155.3,52.54 RC10.2 ; v2(199.7,70.06) 199.8,70.06 RC55.1 201.66,69.48 v1(201.87,69.69) 203.85,71.67 203.85,76.14 201.55,78.44 199.75,78.44 199.34,78.04 JSPI1.4
PCH_SPI_SI_R: length 71.2
  TOP w0.127: v2(199.33,44.77) v1(199.33,44.21)
  IN2 w0.089: v2(199.7,70.7) 200.1,70.3 200.1,68.2 199.59,67.69 199.59,64.29 202.17,61.71 202.17,58.25 202.79,57.62 202.79,54.72 198.64,50.56 198.64,45.46 v2(199.33,44.77)
  IN3 w0.089: v2(199.33,44.77) 190.82,44.77 189.83,43.77 188.33,43.77 187.76,44.34 184.29,44.34 181.91,46.72 179.91,46.72 179.58,47.05 v2(178.93,47.05)
  BOTTOM w0.127: v2(199.7,70.7) 200.08,70.7 RC55.2 202.21,70.39 203.6,71.78 203.6,76.03 201.44,78.19 200,78.19 199.84,78.03 JSPI1.3 ; v2(178.93,47.05) 178.93,47.05 178.77,46.89 177.76,46.89 177.44,47.21 RP5.5 176.47,47.21 176.35,47.34 176.35,48.58 176.48,48.71 RP5.8
PCH_SPI_SI_TPM: length 14.9
  TOP w0.127: U15.21 189,45.57 v2(189.03,45.55)
  IN3 w0.089: v2(180.6,49.18) 181.03,48.75 186.62,48.75 189.03,46.34 v2(189.03,45.55)
  BOTTOM w0.127: v2(180.6,49.18) 180.6,48.61 179.46,47.47 178.76,47.47 178.5,47.21 RP5.4
PCH_SPI_SO: length 71.3
  IN1 w0.081: v2(150.32,51.72) 152.52,49.52 154.12,49.52 155.51,50.92 158.35,50.92 158.96,50.31 163.57,50.31 165.8,52.54 165.8,56.88 166.52,57.6 166.52,60.64 167.44,61.55 167.44,63.16 170.54,66.26 170.54,67.65 171.95,69.05 172.66,69.05 174.64,71.03 176.79,71.03 178.05,72.3 180.41,72.3 181.1,72.98 182.14,72.98 182.5,73.34 188.24,73.34 188.52,73.62 192.76,73.62 195.21,76.07 198.13,76.07 v2(198.35,76.29)
  BOTTOM w0.127: v2(150.32,51.72) 150.4,51.64 UCPU1.AW3 ; JSPI1.6 198.34,77.2 199.47,76.07 RC53.1 199.23,75.49 v1(198.52,75.49) 198.35,75.67 v2(198.35,76.29)
PCH_SPI_SO_R: length 62.5
  TOP w0.127: v2(200.33,46.26) v1(200.33,45.75)
  IN2 w0.089: v2(201.26,75.9) 201.77,75.39 201.77,67.87 202.37,67.27 202.37,65 203.43,63.94 203.43,60.65 203.87,60.21 203.87,54.26 200.33,50.72 v2(200.33,46.26)
  IN3 w0.089: v2(187.68,48.69) 187.81,48.55 188.24,48.55 189.47,47.33 199.42,47.33 200.33,46.42 v2(200.33,46.26)
  BOTTOM w0.127: v2(187.68,48.69) 187.56,48.8 181.15,48.8 179.79,47.44 179.79,47.03 179.11,46.35 177.86,46.35 177.43,45.92 RP6.8 RP6.7 ; JSPI1.5 198.84,77.3 200.38,75.75 RC53.2 201.09,75.73 v2(201.26,75.9)
PCH_SPI_SO_TPM: length 13.1
  TOP w0.127: U15.24 188.42,47.08 188.65,47.31 188.65,47.66 188.33,47.98 v2(188.04,47.98)
  BOTTOM w0.127: v2(188.04,47.98) 187.52,47.98 186.95,48.55 181.26,48.55 180.05,47.34 180.05,46.92 179.04,45.92 RP6.1
PCH_TBT_FORCE_PWR: length 3
  TOP w0.127: v2(148.92,69.94) 148.31,70.54 RC247.1 148.36,70.62 149.05,71.31 v3(149.56,71.31)
  BOTTOM w0.127: UCPU1.D7 148.59,70.26 v2(148.92,69.94)
PCI_CLK_LPC0: length 14.8
  BOTTOM w0.076: 150.78,46.69 150.14,47.33 149.68,47.33 149.45,47.1 149.07,47.1 148.81,47.36 148.81,47.79 147.32,49.28 147.18,49.28 146.86,49.6 146.86,50.53 146.94,50.61 146.94,51.03 147,51.22 147.22,51.44 UCPU1.AW9
  BOTTOM w0.127: v3(155.68,44.37) 155.8,44.49 155.8,45.18 RC18.1 155.45,45.07 155.45,44.95 155.18,44.68 154.04,44.68 153.4,45.32 152.37,45.32 151,46.69 150.78,46.69
PCI_CLK_LPC1: length 11.3
  BOTTOM w0.076: 150.99,47.39 150.57,47.39 149.94,48.03 149.07,48.03 147.65,49.44 147.65,50.02 147.47,50.2 147.47,50.85 147.34,50.99 UCPU1.AY9
  BOTTOM w0.127: 150.99,47.39 152.34,46.03 v3(154.28,46.03) 155.52,46.03 RC22.1
PCIE_PRX_CARDTX_N6: length 109.6
  IN2 w0.076: v2(141.68,68.59) 141.81,68.59 142.04,68.82 142.04,69.05 142.24,69.25 142.24,70.21 142.39,70.36 142.43,70.36 142.44,70.37
  IN2 w0.102: 142.44,70.37 143.38,71.31 149.47,71.31 150.31,70.47 152.26,70.47 152.62,70.82 154.47,70.82 155.03,70.27 157.37,70.27 157.86,69.77 158.03,69.77 159.12,68.67 160.13,68.67 161.97,66.83 164.56,66.83 164.82,67.1 170.14,67.1 170.89,67.86 173.18,67.86 173.28,67.75 174.82,67.75 174.92,67.86 176.64,67.86 177.1,67.39 178.21,67.39 178.43,67.61 184.42,67.61 184.84,67.19 184.84,66.29 185.32,65.8 185.32,65.31 185.72,64.92 187.11,64.92 188.51,63.51 189.43,63.51 190.3,62.64 190.3,60 190.48,59.82 190.48,57.66 190.2,57.38 190.2,53.48 187.87,51.14 187.87,49.53 188.9,48.5 188.9,47.86 189.95,46.81 191.03,46.81 191.9,45.94 191.9,43.88 192.33,43.45 192.33,32.71 199.04,26 199.04,24.55 201.18,22.42 201.93,22.42 202.33,22.02 202.33,21.61 v2(202.11,21.4)
  BOTTOM w0.127: v2(141.68,68.59) 141.84,68.59 UCPU1.G18 ; JIO1.28 202.11,18.58 202.25,18.72 202.25,19.04 202.11,19.18 202.11,20.68 202.29,20.86 202.29,21.22 v2(202.11,21.4)
PCIE_PRX_CARDTX_P6: length 109.8
  IN2 w0.076: 142.28,70.53 142.27,70.52 142.27,70.48 142.08,70.28 142.08,69.32 141.94,69.18 v2(141.68,69.18)
  IN2 w0.102: v2(202.77,21.4) 202.55,21.61 202.55,22.11 202.02,22.64 201.27,22.64 199.26,24.65 199.26,26.09 192.55,32.81 192.55,43.54 192.13,43.97 192.13,46.03 191.13,47.03 190.04,47.03 189.12,47.96 189.12,48.6 188.09,49.63 188.09,51.05 190.42,53.39 190.42,57.29 190.7,57.57 190.7,59.91 190.52,60.09 190.52,62.73 189.52,63.74 188.61,63.74 187.2,65.15 185.81,65.15 185.55,65.41 185.55,65.9 185.06,66.38 185.06,67.28 184.52,67.83 178.33,67.83 178.12,67.62 177.2,67.62 176.73,68.08 174.83,68.08 174.73,67.98 173.38,67.98 173.27,68.08 170.8,68.08 170.05,67.32 164.73,67.32 164.47,67.06 162.06,67.06 160.22,68.9 159.22,68.9 158.12,70 157.96,70 157.46,70.49 155.12,70.49 154.56,71.05 152.52,71.05 152.17,70.7 150.41,70.7 149.57,71.54 143.29,71.54 142.28,70.53
  BOTTOM w0.127: UCPU1.F18 141.92,68.94 v2(141.68,69.18) ; JIO1.26 202.71,18.6 202.5,18.81 202.5,19.15 202.36,19.29 202.36,20.57 202.54,20.76 202.54,21.17 v2(202.77,21.4)
PCIE_PRX_SSDTX_N9: length 79.7
  IN4 w0.091: v2(181.94,24.24) 181.78,24.4 181.02,24.4 180.24,25.19 180.24,25.71 175.34,30.62 175.34,37.99 172.25,41.08 172.25,46.94 171.33,47.86 171.33,51.85 168.91,54.27 168.91,55.83 166.38,58.36 166.38,61.29 165.34,62.33 165.34,62.93 164.59,63.68 163.58,63.68 162.66,64.6 162.66,65.72 162.33,66.05 162.03,66.05 160.58,67.5 159.16,67.5 157.56,69.1 157,69.1 155.3,70.8 152.6,70.8 152.38,70.58 150.36,70.58 149.6,71.34 145.45,71.34 144.37,70.27 143.69,70.27 143.56,70.4 142.55,70.4 142.36,70.22 140.51,70.22 139.69,69.39 139.09,69.39 v2(138.96,69.26)
  BOTTOM w0.127: JNGFF2.5 183.15,24.3 182.42,24.3 182.32,24.4 182.1,24.4 v2(181.94,24.24) ; UCPU1.E22 139.25,69.59 139,69.33 139,69.26 138.96,69.22 v2(138.96,69.26)
PCIE_PRX_SSDTX_N10: length 81.4
  IN4 w0.091: v2(138,69.18) 138,69.34 138.12,69.45 138.35,69.45 138.57,69.66 138.57,70.73 139.48,71.65 142.93,71.65 143.04,71.76 144.47,71.76 144.65,71.94 155.96,71.94 159.21,68.69 160.22,68.69 160.92,67.99 161.15,67.99 162.51,66.63 162.71,66.63 163.33,66.01 163.33,64.83 163.84,64.32 164.86,64.32 166.98,62.19 166.98,58.66 170.65,55 170.65,53.62 171.94,52.33 171.94,48.23 173.06,47.12 173.06,43.29 173.67,42.68 173.67,41.15 175.95,38.87 175.95,32.7 181.18,27.47 184.23,27.47 184.38,27.31 v2(184.38,27.24)
  BOTTOM w0.127: UCPU1.F25 137.76,68.94 v2(138,69.18) ; JNGFF2.17 183.15,27.3 183.93,27.3 184.06,27.43 184.19,27.43 v2(184.38,27.24)
PCIE_PRX_SSDTX_N11: length 84.3
  IN4 w0.091: v2(181.53,30.54) 181.38,30.69 181.08,30.69 180.85,30.93 180.85,31.96 181.15,32.26 181.15,33.39 180.68,33.86 180.68,42.63 180.44,42.87 179.37,42.87 178.6,43.64 177.94,43.64 177.51,44.08 176.64,44.08 173.86,46.86 173.86,47.73 172.93,48.65 172.93,54.11 169.14,57.9 169.14,59.78 167.83,61.09 167.83,62.79 166.08,64.54 166.08,65.63 163.99,67.72 163.99,69.54 163.59,69.94 160.97,69.94 159.89,71.01 158.51,71.01 157.43,72.09 157.43,73.04 156.67,73.8 154.58,73.8 154.03,73.24 150.37,73.24 149.68,72.55 144.35,72.55 144.18,72.38 142.8,72.38 142.67,72.26 139.05,72.26 137.62,70.83 137.62,70.25 136.53,69.16 135.81,69.16 135.57,69.4 135.57,69.65 v2(135.33,69.89)
  BOTTOM w0.127: UCPU1.E28 135.63,69.59 v2(135.33,69.89) ; v2(181.53,30.54) 181.7,30.7 181.87,30.7 182.16,30.42 182.32,30.42 182.44,30.29 JNGFF2.29
PCIE_PRX_SSDTX_P9: length 79.7
  IN4 w0.091: v2(138.97,69.87) 139.26,69.58 139.61,69.58 140.43,70.41 142.28,70.41 142.47,70.6 143.64,70.6 143.77,70.46 144.29,70.46 145.37,71.54 149.68,71.54 150.44,70.77 152.3,70.77 152.52,70.99 155.38,70.99 157.08,69.29 157.64,69.29 159.24,67.69 160.66,67.69 162.11,66.24 162.41,66.24 162.86,65.8 162.86,64.68 163.66,63.88 164.67,63.88 165.53,63.01 165.53,62.41 166.57,61.37 166.57,58.44 169.1,55.91 169.1,54.35 171.53,51.93 171.53,47.94 172.44,47.02 172.44,41.16 175.53,38.07 175.53,30.7 180.43,25.79 180.43,25.27 181.1,24.6 181.71,24.6 v2(181.94,24.82)
  BOTTOM w0.127: UCPU1.E23 138.69,69.59 v2(138.97,69.87) ; v2(181.94,24.82) 182.11,24.65 182.17,24.65 182.32,24.8 183.15,24.8 JNGFF2.7
PCIE_PRX_SSDTX_P10: length 81.4
  IN4 w0.091: v2(184.38,27.85) 184.19,27.66 181.26,27.66 176.14,32.78 176.14,38.95 173.86,41.23 173.86,42.76 173.25,43.37 173.25,47.2 172.14,48.31 172.14,52.41 170.84,53.7 170.84,55.08 167.17,58.74 167.17,62.27 164.94,64.51 163.92,64.51 163.53,64.91 163.53,66.09 162.79,66.83 162.59,66.83 161.23,68.19 161,68.19 160.3,68.88 159.29,68.88 156.04,72.13 144.57,72.13 144.39,71.96 142.96,71.96 142.85,71.84 139.4,71.84 138.37,70.81 138.37,69.74 138.27,69.65 138.06,69.65 137.95,69.76 v2(137.95,69.89)
  BOTTOM w0.127: v2(184.38,27.85) 184.21,27.68 184.01,27.68 183.9,27.8 183.15,27.8 JNGFF2.19 ; UCPU1.E25 137.7,69.59 137.95,69.83 v2(137.95,69.89)
PCIE_PRX_SSDTX_P11: length 84.3
  IN4 w0.091: v2(136.17,69.88) 135.91,69.88 135.76,69.73 135.76,69.48 135.89,69.35 136.45,69.35 137.43,70.33 137.43,70.91 138.97,72.45 142.59,72.45 142.72,72.58 144.1,72.58 144.27,72.74 149.6,72.74 150.29,73.43 153.95,73.43 154.5,73.99 156.75,73.99 157.62,73.12 157.62,72.17 158.59,71.21 159.97,71.21 161.05,70.13 163.67,70.13 164.18,69.62 164.18,67.8 166.27,65.71 166.27,64.62 168.02,62.87 168.02,61.17 169.33,59.86 169.33,57.98 173.13,54.19 173.13,48.73 174.05,47.81 174.05,46.94 176.72,44.27 177.59,44.27 178.02,43.84 178.68,43.84 179.45,43.06 180.52,43.06 180.87,42.71 180.87,33.94 181.35,33.47 181.35,32.18 181.04,31.88 181.04,31.01 181.16,30.89 181.29,30.89 v2(181.53,31.13)
  BOTTOM w0.127: v2(136.17,69.88) 136.45,69.59 UCPU1.E27 ; JNGFF2.31 183.15,30.8 182.53,30.8 182.4,30.67 182.27,30.67 181.98,30.96 181.7,30.96 v2(181.53,31.13)
PCIE_PRX_TBTX_N1: length 119.2
  TOP w0.127: v2(46.85,68.46) 46.69,68.3 46.69,68.09 CT3.1
  IN1 w0.091: v2(46.85,68.46) 46.65,68.27 46.65,68.03 46.89,67.79 48.97,67.79 51.28,70.1 56.49,70.1 56.81,70.43 61.48,70.43 63.35,68.55 72.41,68.55 74.22,70.37 83.09,70.37 83.51,70.79 85.37,70.79 85.74,70.42 86.93,70.42 87.6,71.09 92.44,71.09 92.94,71.59 100.3,71.59 100.63,71.26 105.44,71.26 108.99,74.81 108.99,75.57 109.6,76.18 115.67,76.18 116.07,75.78 116.07,75.1 116.45,74.71 120.98,74.71 121.45,74.24 121.89,74.24 122.18,74.53 122.18,75.65 122.53,76 123.75,76 123.97,76.22 129.85,76.22 130.34,75.73 130.34,74.08 130.55,73.87 135.42,73.87 135.9,73.39 136.84,73.39 137.15,73.7 137.15,74.33 138.63,75.82 142.04,75.82 143.4,74.46 143.4,72.84 145.21,71.03 145.21,68.43 144.9,68.12 144.63,68.12 v2(144.43,67.91)
  BOTTOM w0.127: v2(144.43,67.91) 144.7,67.64 UCPU1.H13
PCIE_PRX_TBTX_N1_C: length 3.2
  TOP w0.076: 45.62,66.43 45.61,66.42 45.57,66.42 45.48,66.34 45.48,65.34 UT1.V22
  TOP w0.127: 45.62,66.43 45.63,66.44 45.63,66.44 45.88,66.68 46.39,66.68 46.63,66.92 46.63,67.15 CT3.2
PCIE_PRX_TBTX_N2: length 120.5
  TOP w0.127: CT7.1 43.71,68.12 43.71,68.31 v2(43.56,68.46)
  IN1 w0.091: v2(43.56,68.46) 43.8,68.23 43.8,68.03 44.93,66.9 49.38,66.9 50.87,68.39 50.89,68.39 50.92,68.42 54.49,68.42 54.7,68.64 56.35,68.64 57.36,69.65 61.08,69.65 62.96,67.76 77.76,67.76 79.55,69.55 83.41,69.55 83.85,69.99 84.99,69.99 85.34,69.63 87.25,69.63 87.88,70.27 93.04,70.27 93.52,70.75 100,70.75 100.29,70.45 105.77,70.45 108.61,73.3 111.44,73.3 112.27,74.13 115.09,74.13 115.29,73.93 120.64,73.93 121.13,73.44 122.23,73.44 122.56,73.12 122.56,72.66 123.72,71.49 126.09,71.49 126.49,71.89 127.38,71.89 127.76,71.51 128.92,71.51 129.4,71.99 137.72,71.99 138.79,73.06 138.79,74.33 139.47,75.02 141.08,75.02 141.92,74.17 141.92,73.65 142.11,73.46 142.56,73.01 142.56,72.55 143.42,71.68 143.42,70.43 143.71,70.14 143.71,67.67 144.06,67.33 144.86,67.33 145.84,68.31 145.84,68.71 145.94,68.81 146.06,68.81 v2(146.25,68.61)
  BOTTOM w0.127: v2(146.25,68.61) 146.12,68.61 UCPU1.G11
PCIE_PRX_TBTX_N2_C: length 2.6
  TOP w0.076: 43.7,66.47 43.7,66.45 43.73,66.41 43.73,66.32 43.18,65.77 43.18,65.36 43.28,65.26 43.28,65.26 UT1.P22
  TOP w0.127: 43.7,66.47 43.67,66.49 43.67,67.22 CT7.2
PCIE_PRX_TBTX_P1: length 119.1
  TOP w0.127: v2(46.26,68.46) 46.43,68.29 46.43,68.11 46.27,67.94 CT1.1
  IN1 w0.091: v2(144.43,68.65) 144.43,68.46 144.58,68.31 144.82,68.31 145.02,68.51 145.02,70.95 143.21,72.76 143.21,74.38 141.96,75.62 138.71,75.62 137.34,74.25 137.34,73.62 136.92,73.2 135.82,73.2 135.34,73.68 130.47,73.68 130.15,74 130.15,75.65 129.77,76.03 124.05,76.03 123.83,75.8 122.61,75.8 122.38,75.57 122.38,74.45 121.97,74.05 121.37,74.05 120.9,74.52 116.37,74.52 115.88,75.02 115.88,75.7 115.59,75.99 109.68,75.99 109.18,75.49 109.18,74.73 105.52,71.06 100.55,71.06 100.22,71.39 93.02,71.39 92.52,70.9 87.68,70.9 87.01,70.22 85.66,70.22 85.29,70.6 83.59,70.6 83.17,70.17 74.3,70.17 72.49,68.36 63.27,68.36 61.4,70.23 56.89,70.23 56.57,69.91 51.36,69.91 49.05,67.6 46.81,67.6 46.44,67.97 46.44,68.28 v2(46.26,68.46)
  BOTTOM w0.127: v2(144.43,68.65) 144.78,68.29 UCPU1.G13
PCIE_PRX_TBTX_P1_C: length 3.2
  TOP w0.076: 45.46,66.59 45.44,66.58 45.44,66.53 45.31,66.41 45.31,66.14 45.03,65.86 45.03,65.5 45.11,65.41 45.21,65.41 45.26,65.46 UT1.V23
  TOP w0.127: 45.46,66.59 45.46,66.62 45.77,66.93 46.29,66.93 46.38,67.03 46.38,67.18 CT1.2
PCIE_PRX_TBTX_P2: length 120.4
  TOP w0.127: CT5.1 44.11,67.94 43.97,68.09 43.97,68.33 44.09,68.46 v2(44.22,68.46)
  IN1 w0.091: v2(146.23,69.25) 145.98,69 145.86,69 145.64,68.79 145.64,68.39 144.78,67.52 144.14,67.52 143.91,67.75 143.91,70.22 143.61,70.51 143.61,71.76 142.75,72.63 142.75,73.09 142.11,73.73 142.11,74.25 141.16,75.21 139.39,75.21 138.59,74.41 138.59,73.14 137.64,72.19 129.32,72.19 128.84,71.7 127.84,71.7 127.46,72.08 126.41,72.08 126.01,71.69 123.8,71.69 122.75,72.74 122.75,73.2 122.31,73.63 121.21,73.63 120.72,74.12 115.37,74.12 115.17,74.32 112.19,74.32 111.36,73.49 108.53,73.49 105.69,70.65 100.37,70.65 100.08,70.94 93.44,70.94 92.96,70.46 87.8,70.46 87.17,69.82 85.42,69.82 85.07,70.18 83.77,70.18 83.33,69.75 79.47,69.75 77.68,67.95 63.04,67.95 61.16,69.84 57.28,69.84 56.27,68.83 54.62,68.83 54.41,68.61 50.83,68.61 49.3,67.09 45.01,67.09 43.99,68.11 43.99,68.23 v2(44.22,68.46)
  BOTTOM w0.127: UCPU1.F11 146.11,69.25 v2(146.23,69.25)
PCIE_PRX_TBTX_P2_C: length 2.8
  TOP w0.076: UT1.P23 43.42,65.43 43.49,65.36 43.61,65.36 43.66,65.41 43.66,65.75 43.59,65.83 43.59,65.94 43.89,66.25 43.89,66.46 43.92,66.49 43.92,66.49
  TOP w0.127: 43.92,66.49 43.92,67.29 43.99,67.36 CT5.2
PCIE_PRX_WLANTX_N5: length 128.6
  IN1 w0.091: v2(41.78,37.52) 41.58,37.73 41.58,37.88 41.73,38.03 42.82,38.03 44.69,39.9 44.69,44.31 46.56,46.18 46.56,47.84 49.77,51.05 49.77,52.35 50.28,52.85 50.96,52.85 52.06,53.96 56.25,53.96 59.16,56.87 59.16,58.84 63.86,63.53 63.86,65.08 65.31,66.54 78.22,66.54 80.01,68.33 92.99,68.33 94.03,69.38 99.52,69.38 100.17,68.73 107.4,68.73 108.05,69.38 108.43,69.38 109.62,70.56 111.15,70.56 112.8,72.21 117.55,72.21 118.5,71.26 122.2,71.26 123.19,70.27 129.08,70.27 129.13,70.21 130.52,70.21 131.08,70.77 132.24,70.77 132.8,70.21 134.95,70.21 135.05,70.32 136.3,70.32 136.4,70.21 137.35,70.21 137.48,70.35 137.98,70.35 138.94,71.31 141.96,71.31 142.25,71.02 142.25,70.58 142.04,70.37 142.04,69.97 142.05,69.96 142.05,69.7 142.28,69.46 142.46,69.46 142.6,69.32 v2(142.6,69.18)
  BOTTOM w0.127: v2(142.6,69.18) 142.64,69.22 142.98,69.22 143.06,69.15 UCPU1.F16 ; JNGFF1.35 41.75,38.15 41.6,38 41.6,37.64 41.72,37.52 v2(41.78,37.52)
PCIE_PRX_WLANTX_P5: length 128.6
  IN1 w0.091: v2(142.64,69.87) 142.64,69.86 142.44,69.66 142.36,69.66 142.24,69.78 142.24,70.04 142.23,70.05 142.23,70.29 142.44,70.5 142.44,71.1 142.04,71.5 138.86,71.5 137.9,70.54 137.4,70.54 137.27,70.41 136.48,70.41 136.38,70.51 134.97,70.51 134.87,70.41 132.88,70.41 132.32,70.97 131,70.97 130.44,70.41 129.21,70.41 129.16,70.46 123.27,70.46 122.28,71.45 118.58,71.45 117.63,72.4 112.72,72.4 111.07,70.75 109.54,70.75 108.35,69.57 107.97,69.57 107.32,68.92 100.25,68.92 99.6,69.57 93.95,69.57 92.91,68.53 79.93,68.53 78.14,66.73 65.23,66.73 63.66,65.16 63.66,63.61 58.96,58.92 58.96,56.95 56.17,54.15 51.98,54.15 50.88,53.04 50.2,53.04 49.58,52.43 49.58,51.13 46.37,47.92 46.37,46.26 44.5,44.39 44.5,39.98 42.74,38.23 41.65,38.23 41.39,37.96 41.39,37.71 v2(41.2,37.52)
  BOTTOM w0.127: v2(41.2,37.52) 41.35,37.67 41.35,38 41.25,38.1 JNGFF1.33 ; UCPU1.E16 142.9,69.59 142.64,69.85 v2(142.64,69.87)
PCIE_PTX_CARDRX_N6: length 114.4
  IN2 w0.102: v2(205.66,22.49) 205.83,22.66 205.83,23.35 202.11,27.07 200.32,27.07 195.51,31.88 195.51,35.65 194.06,37.11 194.06,45.82 192.36,47.52 192.36,52.9 192.76,53.3 192.76,56.99 192.33,57.42 192.33,58.62 192.45,58.74 192.45,59.86 191.56,60.75 191.56,63.21 191.39,63.38 191.39,64.12 189.97,65.54 189.97,67.81 186.65,71.13 180.8,71.13 179.83,72.1 179.26,72.1 177.4,73.95 169.99,73.95 169.44,73.39 167.66,73.39 165.19,70.93 161.13,70.93 159.89,72.17 158.7,72.17 156.34,74.53 152.16,74.53 151.6,75.09 144.22,75.09 144.07,75.24 143.69,75.24 143.19,74.74 141.52,74.74 141.12,74.34 141.12,74.16 140.76,73.8 140.75,73.8 v2(140.34,73.39)
  BOTTOM w0.076: v2(140.34,73.39) 140.56,73.16 140.6,73.12 140.6,72.24 140.43,72.07 140.43,71.71 140.31,71.59 140.31,71.21 UCPU1.D20
  BOTTOM w0.127: v2(205.66,22.49) 205.75,22.49 205.84,22.41 205.84,21.19 205.69,21.04 CH14.1
