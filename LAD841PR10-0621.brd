# Allegro board LAD841PR10-0621.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GNDA_CHG: length 40.4
  TOP w0.381: PC331.2 39.47,24.14 v2(39.01,23.68)
  TOP w0.508: PQ302.3 37.12,21.84 v2(37.64,21.32)
  IN3 w0.508: v2(46,25.21) 45.11,24.32 39.65,24.32 v2(39.01,23.68) ; v2(40.23,33.8) 40.68,34.25 44.81,34.25 v2(45.19,33.87)
  IN4 w0.508: v2(46,25.21) 45.97,25.23 44.15,25.23 41.7,27.68 v2(41.7,29.31)
  BOTTOM w0.254: PC309.1 45.61,23.43 45.75,23.43 45.78,23.45 46.66,23.45 47.12,23.91 47.12,24.72 46.61,25.23 46.03,25.23 v2(46,25.21) 45.59,25.61 44.76,25.61 PC311.2
  BOTTOM w0.381: v2(37.64,21.32) 38,21.32 38.58,21.9 PR310.1 38.56,22.08 37.72,22.08 37.36,22.44 37.36,22.97 38.08,23.68 v2(39.01,23.68) 39.47,24.14 PC331.2
  BOTTOM w0.508: PC336.2 44.06,34.38 PC334.1 44.92,34.13 v2(45.19,33.87) ; PC337.2 40.49,34.06 v2(40.23,33.8) ; PR317.2 40.97,22.39 40.73,22.39 40.21,22.9 40.21,24.11 PC318.1 PC331.2
  vias: v2(40.63,30.38) v2(40.63,28.25) v2(42.77,30.38) v2(42.77,28.25)
VBUS_ACOK: length 83.9
  TOP w0.127: PR248.1 54.84,68.27 55.46,67.65 56.06,67.65 v2(56.46,68.06) ; v2(57.76,57.17) 58.16,56.77 58.23,56.77 58.23,56.76 59.5,56.76 PR213.1 ; PR261.2 56.95,21.22 55.02,23.15 v2(54.92,23.15) ; PR261.2 PC217.1 58,18.46 PU203.1 59.02,18.46 60.71,16.77 60.71,14.26 60.33,13.88 58.88,13.88 PR263.2 ; PR261.2 57.07,20.53 PQ220.1
  IN4 w0.081: v2(54.92,23.15) 54.92,23.5 52.07,26.35 44.68,26.35 43.92,27.11 43.92,30.17 42.57,31.52 42.57,32.85 42.07,33.35 42.07,36.59 48.29,42.81 48.29,46.02 49.75,47.48 49.75,49.3 50.62,50.17 51.48,50.17 57.76,56.46 v2(57.76,57.17) 58.01,57.43 58.01,58.63 56.74,59.9 56.74,67.78 v2(56.46,68.06)
VBUS_HV_DIS#: length 143.8
  TOP w0.127: PR274.2 92.47,67.9 93.42,68.86 93.42,70.35 PR287.1 93.29,70.71 93.29,71.69 93.95,72.35 93.95,73.53 95.12,74.7 PD206.1 97.04,74.7 98,75.66 99.12,75.66 102.16,78.7 105.91,78.7 107.23,77.39 107.23,76.96 107.93,76.26 107.93,75.67 108.7,74.9 108.7,74.45 108.57,74.33 108.57,73.23 109.09,72.71 112.9,72.71 113.08,72.53 113.85,72.53 114.08,72.75 114.08,73.3 114.75,73.97 121.71,73.97 122.33,74.58 122.33,75.59 122.69,75.95 128.28,75.95 129.34,77.01 v2(129.6,77.01) ; v2(185.88,60.28) 185.88,60.14 186.18,59.85 186.74,59.85 186.82,59.77 UE5.B2
  IN1 w0.081: v2(166.35,77.52) 167.71,78.88 174.57,78.88 v2(175.08,78.37)
  IN3 w0.089: v2(129.6,77.01) 129.6,77.24 130.42,78.05 139.97,78.05 140.87,77.14 145.55,77.14 145.9,76.79 151.66,76.79 153.01,75.44 153.2,75.44 154.04,75.44 154.25,75.22 156.32,75.22 157.33,76.23 157.33,76.67 157.71,77.05 159.74,77.05 160.51,77.82 166.06,77.82 v2(166.35,77.52) ; v2(185.88,60.28) 186.28,59.88 186.64,59.88 187.07,59.46 187.07,59.37 187.89,58.54 189.63,58.54 191.61,60.52 192.39,60.52 192.94,61.07 192.94,61.61 193.85,62.52 193.85,65.13 194.05,65.34 194.05,66.26 194.92,67.13 194.92,67.67 193.25,69.34 193.25,70.36 192.11,71.5 191.88,71.5 189.47,73.91 186.2,73.91 184.36,75.76 177.56,75.76 175.08,78.23 v2(175.08,78.37)
VBUSSENSE: length 3.1
  TOP w0.127: v1(151.61,56.92) 151.61,57.29 RC20.1 150.32,57.93 v2(149.99,57.59)
  BOTTOM w0.127: v2(149.99,57.59) 149.99,58.02 UCPU1.AG4
VCC0V9_LVR_OUT: length 8.2
  TOP w0.203: UT1.F18 40.22,62.79 v2(40.22,62.79) UT1.H18 ; UT1.H11 40.55,59.87 v2(40.87,60.19) 41.2,59.87 UT1.J11
  TOP w0.254: CT98.1 33.65,65.27 CT95.1 CT96.1 31.48,65.25 CT97.1 30.61,64.46 30.35,64.2 v1(30.22,64.2) 29.98,64.2 29.77,64.41 29.77,64.73 v2(29.46,65.03)
VCC0V9_SVR: length 4.8
  TOP w0.127: v2(36.36,59.09) v1(36.36,58.45)
  TOP w0.203: UT1.F12 39.58,60.19 v2(39.58,60.19) 39.58,60.19 UT1.F11 ; UT1.F13 39.9,61.17 v2(39.58,60.84) ; UT1.E12 39.25,60.52 v2(39.58,60.84) ; v2(39.58,60.84) 39.25,61.17 UT1.E13 ; UT1.F15 v2(39.58,61.49)
  TOP w0.229: v2(42.18,59.54) 42.5,59.22 UT1.M9 ; UT1.L9 41.85,59.22 v2(41.52,59.54) 41.2,59.22 UT1.J9
  vias: v2(32.33,52.04) v2(32.35,51.21) v2(32.36,50.37) v2(32.36,49.61) v2(36.16,60.28) v2(36.25,59.69)
VCC1V8A_TBT_LDO: length 7
  TOP w0.127: RT201.2 18.31,68.25 18.31,69.1 18.85,69.64 v1(19.03,69.64)
  TOP w0.152: U722.K1 21.4,64.59 21.4,64.64 20.68,65.35 20.55,65.35 19.66,66.24 CT151.1 19.66,66.41 18.78,67.3 RT201.2
VCC1V8D_TBT_LDO: length 3.3
  TOP w0.152: U722.A2 26.27,63.97 27.08,64.78 28.35,64.78 CT152.1
VCC3V3_TBT_LDO: length 106.1
  TOP w0.203: U722.G1 23.01,64.48 23.01,65.19 v2(22.91,65.29)
  TOP w0.305: RT17.1 RT16.1 RT18.1 51.26,38.25 51.26,37.25 50.9,36.89 49.81,36.89 48.9,35.98 48.26,35.98 47.8,36.43 44.73,36.43 44.26,35.96 42.66,35.96 42.31,36.31 42.31,36.71 43,37.39 43,38.05 UT5.8
  TOP w0.381: CT47.1 40.79,38.31 39.27,36.79 38.79,36.79 v2(38.76,36.81) ; v2(29.78,62.42) 29.63,62.57 R1460.1 R1454.1 29.24,63.51 R1475.1 ; R1478.1 17.62,64.73 v2(17.13,65.21)
  TOP w0.508: UT6.8 20.42,47.14 20.88,47.6 C1346.1 21.13,47.84 v2(21.51,47.46) 21.81,47.75 R1476.1 ; R1474.1 R1477.1 v2(20.19,38.11)
  IN1 w0.508: v2(20.19,38.11) 21.51,39.43 v2(21.51,47.46)
  IN2 w0.508: v2(29.78,62.42) 28.17,64.03 28.17,65.26 27.31,66.13 24.38,66.13 23.54,65.29 v2(22.91,65.29)
  IN3 w0.381: v2(20.19,38.11) 24.09,42.01 25.31,42.01 25.63,42.33 27.13,42.33 28.27,41.18 31.52,41.18 32.36,40.34 32.36,39.81 32.82,39.35 33.42,39.35 34.58,38.19 37.31,38.19 38.68,36.81 v2(38.76,36.81)
  IN3 w0.508: v2(21.82,56.9) 21.17,57.56 21.17,58.61 21.41,58.85 21.41,59.31 20.78,59.94 18.79,59.94 18.03,60.7 16.31,60.7 15.81,61.2 15.81,63.25 15.09,63.98 15.09,65.27 15.62,65.8 16.55,65.8 v2(17.13,65.21) 18.3,66.38 21.82,66.38 v2(22.91,65.29)
  IN4 w0.508: v2(21.82,56.9) 21.82,56.93 21.21,56.32 21.21,54.06 22.71,52.56 22.71,48.65 v2(21.51,47.46)
  BOTTOM w0.508: v2(21.82,56.9) 21.55,57.17 RT199.2
VCC3V3_TBT_SX: length 3.3
  TOP w0.076: 21.76,64.66 21.76,64.38 21.92,64.22 22.26,64.22 U722.H2
  TOP w0.152: C1345.1 20.42,66 21.76,64.66
VCC_3V3_PCIE: length 14.8
  TOP w0.127: v1(44.13,70.8) 44.17,70.77 CT99.1
  TOP w0.203: v2(41.52,62.14) 41.52,62.14 UT1.L16
  TOP w0.381: v2(44.76,69.68) 44.46,69.97 CT99.1
  IN2 w0.381: v2(41.52,62.14) 41.53,62.13 41.58,62.18 41.58,64.55 42.09,65.06 43.56,65.06 45.03,66.53 45.03,67.37 44.78,67.62 43.46,67.62 42.98,68.11 42.98,68.87 43.79,69.68 v2(44.76,69.68)
VCC_3V3_USB2: length 6.4
  TOP w0.127: UT1.J16 40.88,62.14 v2(40.87,62.14) ; v2(40.34,66.68) 40.34,67.04 40.22,67.15 CT100.1
  IN4 w0.081: v2(40.34,66.68) 40.62,66.4 40.62,65.39 41.34,64.67 41.34,62.61 40.87,62.14 v2(40.87,62.14)
VCC_EDRAM_SENSE: length 49.9
  IN2 w0.102: v2(89.05,34.27) 89.05,34.2 88.67,33.82 88.24,33.82 87.99,34.07 87.99,34.96 87.61,35.34 87.61,37.03 88.3,37.73 92.2,37.73 92.53,37.4 96.78,37.4 98.44,39.05 98.44,42.21 102.56,46.34 104,46.34 107.36,49.7 107.36,51.11 108.2,51.95 108.71,51.95 108.97,52.21 108.97,54.15 109.54,54.72 110.43,54.72 112.52,56.82 112.52,57.99 113.78,59.24 116.43,59.24 116.69,59.5 116.69,59.83 116.46,60.05 v2(116.46,60.21)
  BOTTOM w0.254: PR1509.2 89.51,34.89 89.05,34.44 v2(89.05,34.27) ; UCPU1.AC63 116.46,60.45 v2(116.46,60.21)
VCC_EOPIO_SENSE: length 54.2
  IN2 w0.102: v2(116.08,55.64) 115.58,56.14 113.41,56.14 112.14,54.87 112.14,53.6 110.97,52.43 110.59,52.43 109.58,51.42 109.58,48.45 106.5,45.37 104.29,45.37 103.61,44.69 102.78,44.69 99.72,41.63 99.72,38.36 97.03,35.67 94.64,35.67 94.36,35.39 93.73,35.39 92.99,36.13 90.8,36.13 90.07,35.4 90.07,34.02 88.63,32.58 88.21,32.58 87.86,32.22 87.86,29.42 87.08,28.64 87.08,25.25 87.4,24.93 v2(87.38,24.93)
  BOTTOM w0.076: v2(116.08,55.64) 116.59,56.07 UCPU1.AL63
  BOTTOM w0.127: v2(87.38,24.93) 87.81,25.36 88.34,25.36 PR1520.2
VCC_GT_SENSE: length 81
  TOP w0.203: v2(68.73,48.85) 68.68,48.8 PR1093.1 68.68,48.09 69.7,47.08 PC1014.1
  TOP w0.254: RC161.2 109.32,67.01 v2(109.32,67.04)
  IN2 w0.254: v2(68.73,48.85) 68.43,49.16 68.43,49.87 66.52,51.77 66.52,56.6 67.16,57.24 67.16,58.84 67.74,59.42 70.46,59.42 71.55,60.51 71.55,65.49 72.67,66.61 74.19,66.61 75.46,67.88 75.46,69.07 v2(75.36,69.17)
  BOTTOM w0.076: 109.76,67.27 109.81,67.32 111.01,67.32 111.17,67.17 111.59,67.17 111.84,67.28 111.84,67.29 111.85,67.29 111.99,67.43 UCPU1.J70
  BOTTOM w0.203: 109.76,67.27 109.55,67.27 v2(109.32,67.04) 107.95,67.04 107.14,67.85 107.14,69.73 106.15,70.72 105.87,70.72 102.18,70.72 99.72,73.19 99.72,74.02 98.7,75.04 95.61,75.04 93.4,72.83 93.4,71.76 92.99,71.36 92.99,69.49 91.52,68.02 86.77,68.02 84.39,70.4 83.8,70.4 82.91,69.5 v3(81.71,69.5) 79.41,69.5 78.93,69.99 76.02,69.99 75.36,69.34 v2(75.36,69.17) ; PC1098.2 PR1093.1 68.68,48.8 v2(68.73,48.85)
VCCIO_SENSE: length 48
  TOP w0.203: PR1409.2 172.19,45.37 171.98,45.17 170.6,45.17 v3(170.38,45.39) 170,45.76 167.69,45.76 167.52,45.93 163.52,45.93 163.45,45.86 161.89,45.86 161.84,45.91 v2(161.78,45.97)
  TOP w0.254: v2(138.03,55.66) 137.39,56.3 RC165.2
  IN2 w0.254: v2(161.78,45.97) 161.68,45.86 161.31,45.86 160.56,45.12 159.36,45.12 158.52,45.96 157.5,45.96 155.92,47.53 155.92,47.99 155.25,48.67 152.81,48.67 151.7,49.78 151.7,53.62 148.63,56.69 148.63,57.93 147.55,59.01 140.18,59.01 139.55,58.38 139.55,57.29 138.03,55.76 v2(138.03,55.66)
  BOTTOM w0.254: v2(138.03,55.66) 138.42,56.05 UCPU1.AM23
VCCSENSE: length 89.7
  TOP w0.127: RC140.2 134.9,71.22 134.88,71.24 134,71.24 133.49,70.73 v2(133.49,69.81)
  TOP w0.203: PR1079.1 PC1090.1 74.91,54.92 PC1132.2 PC1092.1 73.61,54.95 v2(73.03,54.36)
  IN2 w0.089: v2(133.49,69.81) 133.86,69.43 133.86,68.54 133.17,67.84 127.6,67.84 127.29,67.53 124.04,67.53 122.88,66.37 120.26,66.37 119.93,66.04 118.84,66.04 118.3,65.5 118.3,64.94 117.96,64.6 117.96,64.35 117.58,63.97 116.43,63.97 114.99,62.52 111.61,62.52 110.91,63.22 100.7,63.22 100.52,63.39 98.24,63.39 97.03,64.6 97.03,66.1 96.09,67.04 83.19,67.04 82.08,65.93 79.74,65.93 79.3,66.38 78.08,66.38 77.62,65.92 77.62,62.09 78.77,60.94 78.77,58.12 77.37,56.73 75.82,56.73 74.05,54.96 73.27,54.96 73.03,54.72 v2(73.03,54.36)
  BOTTOM w0.127: UCPU1.E32 133.71,69.59 v2(133.49,69.81) ; v3(74.27,52.88) 74.13,52.88 73.03,53.98 v2(73.03,54.36)
VCCST_EN: length 76.6
  TOP w0.127: RE103.1 198.21,54.63 198.21,55.59 ; 198.21,55.59 198.21,55.87 197.33,56.74 197.33,60.98 197.9,61.55 197.9,64.22 197.61,64.51 193.87,64.51 v2(192.75,65.63) ; 198.21,55.59 UC13.4 ; UZ25.4 157.42,76.33 157.61,76.51 v2(158.09,76.51)
  IN3 w0.089: v2(158.09,76.51) 158.31,76.74 158.98,76.74 159.26,76.46 159.26,74.01 161.6,71.66 164.62,71.66 167.2,74.24 167.2,76.98 v2(167.51,77.3)
  BOTTOM w0.127: v2(167.51,77.3) 169.32,77.3 170.66,78.65 173.31,78.65 174.88,77.07 176.82,77.07 177.23,76.67 177.23,76.46 177.83,75.87 178.4,75.87 178.69,75.57 181.05,75.57 181.55,75.08 182.97,75.08 183.23,74.82 184.24,74.82 184.85,75.42 184.85,75.69 186.76,77.61 186.76,77.95 187.08,78.26 189.62,78.26 190.02,77.86 190.02,76.68 190.86,75.85 190.86,74.25 192.46,72.64 192.75,72.64 193.97,71.42 193.97,68.24 194.63,67.58 194.63,66.81 194.45,66.63 194.45,66.33 193.53,65.41 192.97,65.41 v2(192.75,65.63)
VCCST_PWRGD: length 9
  BOTTOM w0.076: UCPU1.B65 115.04,71.87 115.04,72.09 114.99,72.21 114.99,72.47 115.18,72.66 115.18,73.2 114.47,73.91 112.26,73.91 112.09,74.08
  BOTTOM w0.127: v3(109.7,76.29) 110.77,76.29 RC78.2 111.05,76.01 111.05,75.12 112.09,74.08
VCCSTG_EN: length 69.9
  TOP w0.254: PR1401.1 176.61,54.15 177.35,54.15 178.33,53.17 v2(180.18,53.17) ; v2(166.76,68.25) 167.07,68.25 RZ75.1 167.5,67.74 166.17,67.74 UZ19.4 166.17,68.92 UC9.4
  TOP w0.381: RZ76.1 166.85,49.18 166.51,49.53 166.16,49.53 165.79,49.89 161.1,49.89 159.48,51.52 159.48,51.62 158.85,52.25 158.85,55.5 159.61,56.27 v2(159.61,57.97)
  IN1 w0.381: v2(166.76,68.25) 165.78,67.27 165.22,67.27 161.16,63.21 161.16,61.77 159.44,60.05 159.44,59.71 158.97,59.24 158.97,58.71 159.61,58.06 v2(159.61,57.97)
  IN2 w0.254: v2(180.18,53.17) 180.03,53.17 177.75,50.89 177.75,49.86 177.24,49.35 176.84,49.35 174.61,51.58 174.61,55.7 173.53,56.78 173.53,57.59 173.56,57.62 173.56,58.03 173.07,58.52 172.59,58.52 172.39,58.33 171.31,58.33 170.85,58.78 169.41,58.78 168.56,57.93 164.88,57.93 164.06,58.75 164.06,59.29 163.62,59.72 163.09,59.72 161.27,57.9 159.84,57.9 159.76,57.97 v2(159.61,57.97)
VIN_1V_PRIM:
  vias: v2(83.17,29.99) v3(80.62,30.95)
VIN_PRIM:
  vias: v3(201.43,77.92)
VIN_VCC_EDRAM:
  vias: v2(85.77,40.1) v3(85.7,39.33)
VIN_VCCIO:
  vias: v2(176.88,50.48) v2(177.04,49.83) v2(177.09,51.7) v3(176.33,50.3)
VSS_EDRAM_SENSE: length 48.6
  TOP w0.127: v2(88.47,34.3) v3(87.61,33.44)
  TOP w0.254: PR1510.2 88.47,34.78 v2(88.47,34.3)
  IN2 w0.102: v2(117.7,59.52) 117.1,59.52 116.54,58.96 113.89,58.96 112.8,57.87 112.8,56.7 110.54,54.44 109.65,54.44 109.25,54.03 109.25,52.06 108.88,51.7 108.35,51.7 107.64,50.99 107.64,49.58 104.12,46.06 102.82,46.06 98.82,42.06 98.82,38.89 96.94,37.02 92.37,37.02 92.04,37.35 89.7,37.35 89.02,36.67 89.02,36.03 88.47,35.49 v2(88.47,34.3)
  BOTTOM w0.254: v2(117.7,59.52) 117.46,59.77 UCPU1.AE63
VSS_EOPIO_SENSE: length 59.4
  TOP w0.127: v3(83.14,25.6) 83.14,24.85 83.49,24.5 85.87,24.5 86.16,24.78 v2(86.16,24.95)
  IN2 w0.102: v2(86.16,24.95) 86.85,25.64 86.85,28.74 87.63,29.52 87.63,32.39 88.04,32.81 88.54,32.81 89.73,34 89.73,35.44 90.79,36.51 94.64,36.51 95.1,36.05 96.8,36.05 99.33,38.58 99.33,41.78 102.62,45.07 103.45,45.07 107.93,49.54 107.93,50.81 108.59,51.47 109.2,51.47 110.57,52.84 110.8,52.84 111.79,53.83 111.79,55.08 113.37,56.66 113.37,57.07 114.28,57.97 115.82,57.97 115.88,57.92 116.66,57.92 116.84,58.1 v2(117.65,58.1)
  BOTTOM w0.254: PR1521.2 86.34,25.13 v2(86.16,24.95) ; v2(117.65,58.1) 117.48,58.1 117.16,57.78 UCPU1.AJ62
VSS_GT_SENSE: length 81.5
  TOP w0.203: RC163.1 107.44,67.17 v2(106.81,67.17) ; PU1000.6 69.16,51.01 69.16,49.56 v2(68.99,49.39)
  IN2 w0.254: v2(75.95,69.2) 75.87,69.12 75.87,67.75 74.35,66.23 72.83,66.23 71.93,65.33 71.93,60.35 70.62,59.04 67.9,59.04 67.54,58.68 67.54,57.08 66.9,56.44 66.9,52.03 68.81,50.12 68.81,49.56 v2(68.99,49.39)
  BOTTOM w0.076: UCPU1.J69 112.58,67.43 112.32,67.17 112.04,67.17 111.62,67 111.1,67 110.96,67.13 110.28,67.13 109.91,66.76
  BOTTOM w0.203: v2(75.95,69.2) 75.95,69.45 76.15,69.66 78.79,69.66 79.43,69.02 v3(79.96,69.02) 82.89,69.02 83.94,70.07 84.26,70.07 86.64,67.69 91.66,67.69 93.32,69.35 93.32,71.22 93.73,71.63 93.73,72.69 95.74,74.71 98.57,74.71 99.39,73.89 99.39,73.05 102.05,70.39 106.01,70.39 106.81,69.6 v2(106.81,67.17) 107.37,66.61 109.76,66.61 109.91,66.76 ; v2(68.99,49.39) 68.96,49.36 68.38,49.36 67.77,48.75 PC1022.2 67.77,47.38 PC1019.2
VSSIO_SENSE: length 48.1
  TOP w0.203: v2(161.78,45.38) 161.9,45.51 161.97,45.51 161.99,45.53 163.59,45.53 163.66,45.6 167.38,45.6 167.57,45.41 168.54,45.41 v3(168.63,45.33) 169.12,44.84 172.36,44.84 173.08,45.55 PR1410.2
  TOP w0.381: v2(138.94,55.66) 138.28,56.32 RC167.1
  IN2 w0.254: v2(138.94,55.66) 138.94,56.14 139.93,57.13 139.93,58.22 140.34,58.63 147.36,58.63 148.25,57.74 148.25,56.54 151.32,53.46 151.32,49.62 152.66,48.29 155.09,48.29 155.54,47.83 155.54,47.38 157.34,45.58 158.37,45.58 159.2,44.74 160.72,44.74 161.46,45.48 161.67,45.48 v2(161.78,45.38)
  BOTTOM w0.254: v2(138.94,55.66) UCPU1.AM22
VSSSENSE: length 87.8
  TOP w0.127: RC141.1 135.43,70.31 134.25,70.31 133.91,69.97 133.91,69.64 133.49,69.21 v2(133.46,69.21)
  TOP w0.203: PC1099.2 74.85,55.86 PC1092.2 73.28,55.86 v2(73,55.58) 73,55.08 72.49,54.56 71.51,54.56 PU1000.18
  IN2 w0.089: v2(133.46,69.21) 133.41,69.21 132.92,68.73 132.92,68.36 132.61,68.06 127.51,68.06 127.2,67.75 123.95,67.75 122.79,66.59 120.18,66.59 119.84,66.25 118.75,66.25 118.09,65.59 118.09,65.03 117.88,64.83 116.97,64.83 115.57,63.43 100.79,63.43 100.61,63.61 98.32,63.61 97.24,64.69 97.24,66.19 96.18,67.26 83.1,67.26 81.99,66.15 79.83,66.15 79.39,66.59 77.99,66.59 77.41,66.01 77.41,62 78.55,60.85 78.55,58.21 77.28,56.94 75.73,56.94 73.96,55.18 73.25,55.18 73,55.43 v2(73,55.58)
  BOTTOM w0.127: v2(133.46,69.21) 133.09,69.59 UCPU1.E33 ; v3(72.64,56.78) 72.64,55.94 v2(73,55.58)
+AC_IN: length 4.4
  TOP w0.381: PQ213.3 54.89,62.72 56.2,61.41 v2(56.33,61.41)
  TOP w0.508: PQ213.3 54.38,63.59 54.13,63.84 PR233.1
  vias: v2(48.97,77.1) v2(48.97,76.51) v2(49.56,77.1) v2(49.56,76.51) v2(50.14,77.1) v2(50.14,76.51) v2(50.72,77.1) v2(50.72,76.51) v2(58.04,65.77) v2(58.32,65.24) v2(58.47,66.18) v2(59.08,66.24) v2(59.46,65.78)
+DC_IN: length 43.5
  TOP w0.508: PR208.1 34.05,77.47 v3(34.27,77.25) 35.55,75.97 v3(36.14,75.97) v2(36.62,75.49) ; PD204.2 57.81,66.91 57.15,66.25 v2(55.93,66.25)
  IN1 w0.508: v2(36.62,75.49) 36.62,77.11 35.92,77.81 32.01,77.81 v2(31.39,77.2)
  IN2 w0.508: v2(36.62,75.49) 37.24,74.88 37.24,70.33 37.97,69.59 37.97,68.07 38.57,67.47 41.02,67.47 v2(41.76,66.73)
  BOTTOM w0.508: v2(41.76,66.73) 42.45,67.43 48.69,67.43 49.61,66.51 51.58,66.51 53.09,68.02 54.95,68.02 55.45,67.52 55.45,66.67 55.87,66.25 v2(55.93,66.25)
  vias: v2(29.41,77.71) v2(29.87,77.33) v3(30.81,76.64)
+DC_IN_SS: length 120.9
  TOP w0.508: PD301.2 37.69,17.23 38.38,16.55 38.62,16.55 39.22,15.95 39.22,14.53 v2(39.05,14.35) ; PR266.1 v2(65.76,13.8)
  IN2 w0.508: v2(33.9,75.02) 33.9,73.37 31.51,70.97 30.05,70.97 29.54,71.48 26.34,71.48 24.31,69.45 24.31,67.33 23,66.02 21.86,66.02 21.22,65.38 21.22,64.04 21.29,63.98 21.29,60.09 21.24,60.04 21.36,59.93 21.36,58.12 21.79,57.69 24.94,57.69 25.79,56.85 25.79,54.3 27.39,52.7 27.39,48.88 28.17,48.1 29.68,48.1 31.55,46.23 31.55,44.1 33.48,42.17 33.48,41.25 33.55,41.17 33.55,39.15 34.13,38.58 34.13,32.74 33.15,31.76 33.15,25.87 31.47,24.19 31.47,23.37 30.53,22.44 30.53,20.35 31.22,19.67 33.4,19.67 37.26,15.81 37.26,15.62 37.95,14.93 38.48,14.93 v2(39.05,14.35) 39.25,14.15 42.87,14.15 43.45,14.73 50.9,14.73 51.8,15.63 53.91,15.63 54.51,15.04 63.51,15.04 64.75,13.8 v2(65.76,13.8)
  BOTTOM w0.127: v2(39.05,14.35) 37.93,13.23 36.73,13.23 v3(36.59,13.38)
+DCIN_JACK: length 12.2
  TOP w0.127: PC105.1 23.25,78.19 v3(22.89,78.55) ; 28.45,78.67 30.84,78.67 31.46,79.29 32.86,79.29 33.64,78.51 35.18,78.51 v3(35.68,79.01)
  TOP w0.508: v2(26.9,78.32) PC103.1 24.99,78.32 PC104.1 PC105.1
  vias: v2(27.53,78.32) v3(28.17,78.34)
+INV_PWR_SRC:
  vias: v2(193.8,26.3) v2(193.8,25.72) v3(193.88,21.88) v3(194.76,25.98) v3(199.88,22.62)
+LCDVDD: length 0.9
  TOP w0.381: 202.16,31.96 202.16,31.96 R289.1
  vias: v2(193.9,35.14) v2(193.91,34.55) v3(197.61,34.27) v3(200.61,34.96) v3(202.16,33.54)
+PBATT: length 65.8
  TOP w0.254: PD300.2 41.77,20.16 41.25,19.64 v2(41.25,18.98)
  IN1 w0.254: v2(41.25,18.98) 41.25,19.11 39.88,20.48 38.74,20.48 38.25,20.96 38.25,21.47 37.43,22.3 37.43,23.95 36.36,25.02 36.36,30.95 39.23,33.82 v2(39.42,33.82)
  IN4 w0.406: v2(76.99,24.11) 74.17,24.11 67.01,16.95 65.35,16.95 64.21,15.81 58.88,15.81 55.63,19.06 55.09,19.06 54.74,18.7 54.74,18.11 53.78,17.15 51.34,17.15 49.76,15.58 43.56,15.58 41.25,17.89 v2(41.25,18.98)
  BOTTOM w0.254: PR324.2 39.22,34.02 v2(39.42,33.82)
+PP_HV: length 63.7
  TOP w0.254: U722.A8 26.55,60.97 v2(26.65,61.07)
  TOP w0.508: PR289.1 62.69,57.59 63.07,57.97 v2(63.55,57.97) ; PD205.2 59.59,68.27 v2(60.26,68.94)
  IN2 w0.508: v2(31.71,74.42) 32.11,74.81 32.11,75.64 33.24,76.78 34.46,76.78 34.87,76.37 35.68,76.37 36.09,76.78 38.31,76.78 39.41,77.87 41.85,77.87 43.24,79.27 53.77,79.27 54.14,79.64 v2(54.44,79.64)
  IN3 w0.508: v2(63.55,57.97) 62.95,57.97 62.52,57.55 61.73,57.55 61.28,58 61.28,58.42 60.6,59.09 59.13,59.09 v2(58.41,59.81)
  IN4 w0.508: v2(58.41,59.81) 58.41,62.1 59.89,63.57 59.89,64.47 60.08,64.67 60.08,66.77 60.05,66.81 60.05,68.73 v2(60.26,68.94) 60.26,68.94 61.14,69.82 61.14,72.89 59.75,74.28 59.75,76.74 60.47,77.45 60.47,78.12 60.06,78.54 59.32,78.54 58.22,79.64 v2(54.44,79.64)
  BOTTOM w0.127: v2(31.71,74.42) 32.19,74.42 v1(32.43,74.18)
  vias: v2(26.54,61.88) v2(27.14,61.68) v2(28.49,61.78) v2(28.47,61.16)
+PWR_SRC_AC: length 2.8
  BOTTOM w0.127: v3(47.6,33.74) 47.6,33.4 PL300.1
+RTC_CELL_VBAT: length 7.3
  TOP w0.254: v2(184.63,59.81) 184.45,59.63 184.45,59.1 184.61,58.93 UE5.B64
  BOTTOM w0.381: CE65.1 187.17,57.34 186.38,58.14 v1(186.3,58.14) 185.35,58.14 184.52,58.96 184.52,59.71 v2(184.63,59.81)
  BOTTOM w0.508: CE65.1 RE32.2
+RTCBATT: length 4.2
  TOP w0.508: RTCR1.2 C2973.1 15.45,9.74 v2(15.91,9.28)
  BOTTOM w0.508: v2(15.91,9.28) 15.91,9.28 JRTC1.1
+RTCVCC: length 298.1
  TOP w0.254: CC213.1 145.39,49.27 146.58,48.08 146.58,45.93 146.36,45.7 146.36,45.07 146.91,44.51 RC56.2 147.17,44.51
  TOP w0.305: CC270.1 144.42,49.74 v2(143.93,49.25)
  TOP w0.457: v2(44.7,31.71) 46.41,31.71 50.14,27.97 50.14,25.82 51.44,24.52 54.53,24.52 56.21,22.84 58.52,22.84 59.46,23.78 60.12,23.78 60.58,24.24 60.58,25.61 61.09,26.12 v3(63.4,26.12) 66.7,26.12 68.61,28.03 77.32,28.03 79.17,29.88 80.68,29.88 81.93,28.63 86.39,28.63 87.31,27.72 87.31,27.37 87.9,26.79 88.84,26.79 89.53,26.1 93.62,26.1 93.95,26.43 93.95,27.73 94.45,28.23 96.24,28.23 96.75,27.72 v2(98.3,27.72)
  TOP w0.508: CC270.1 CC213.1 ; v2(24.03,34.65) 24.31,34.38 RA54.1 ; RA16.1 17.37,22.52 15.9,21.04 v2(15.9,16.07) C1309.1 CH95.1 15.04,13.19 D122.3 ; v2(36.6,33.24) 36.58,33.27 35.45,33.27 35.28,33.11 33.16,33.11 32.91,32.85 v2(30.91,32.85) ; 147.17,44.51 RC69.2 RC57.2 ; v2(189.33,51.65) 188.95,52.03 RE31.1
  IN1 w0.508: v2(24.03,34.65) 26.25,34.65 26.46,34.87 28.94,34.87 30.23,33.59 30.23,33.54 v2(30.91,32.85) 30.91,27.95 31.4,27.46 31.4,24.95 27.45,20.99 26.98,20.99 25.8,19.82 17.49,19.82 15.9,18.23 v2(15.9,16.07)
  IN2 w0.508: v2(175.72,51.8) 175.72,52.65 176.13,53.06 178.12,53.06 180.12,55.06 182.21,55.06 183.54,53.73 v2(183.54,53.29) ; 144.07,50.07 144.83,50.07 146.89,48.02 146.89,45.4 149.53,42.76 154.05,42.76 154.66,42.15 156.16,42.15 158.79,39.52 160.31,39.52 v2(160.5,39.71)
  IN3 w0.508: v2(160.5,39.71) 160.76,39.71 162.22,41.18 163.03,41.18 164.57,42.72 166.69,42.72 167.38,43.41 169.39,43.41 169.76,43.04 171.71,43.04 172.32,43.65 173.25,43.65 173.71,43.19 174.45,43.19 175.16,43.9 175.16,48.22 175.63,48.68 175.63,51.71 v2(175.72,51.8) ; v2(183.54,53.29) 183.54,53.93 185.24,55.63 187.57,55.63 v2(188.37,54.83) ; v2(189.33,51.65) 190.12,52.43 190.83,52.43 192.06,51.21 v2(193.02,51.21) 193.78,51.97 193.78,53.43 193.04,54.16 193.04,57.69 v2(193.05,57.7) ; v2(36.6,33.24) 38.65,33.24 39.07,32.83 40.71,32.83 41.17,33.28 44.02,33.28 44.7,32.6 v2(44.7,31.71)
  BOTTOM w0.152: UCPU1.BB14 144.13,49.46 v2(143.93,49.25)
  BOTTOM w0.254: v2(140.79,56.3) 141.39,56.82 UCPU1.AK19
  BOTTOM w0.508: v2(189.33,51.65) 189.33,52.75 189.16,52.92 189.16,54.32 188.65,54.83 v2(188.37,54.83) 188.06,55.14 RE32.1 ; v2(160.5,39.71) 159.3,39.71 158.93,40.07 156.06,40.07 153.09,37.09 151.51,37.09 150.98,37.63 117.58,37.63 116.51,38.69 106.47,38.69 103.15,35.37 101.73,35.37 98.63,32.27 98.63,31.63 98.78,31.48 98.78,30.95 97.71,29.88 97.71,28.3 v2(98.3,27.72) ; v2(193.02,51.21) 193.02,51.28 192.14,52.16 RE36.1
+SDC_IN: length 83.3
  TOP w0.508: PR204.1 18.59,73.52 19.74,74.66 ; v2(20.09,73.64) 19.74,74 19.74,74.66 ; 19.74,74.66 PQ205.3 19.74,75.36 20.66,76.29 PR206.1
  IN1 w0.508: v4(48.24,24.71) 47.13,25.82 45.16,25.82 44.55,25.21 41.86,25.21 41.17,25.89 41.17,26.25 39.68,27.74 39.68,30.47 41.4,32.19 41.4,32.8 42.45,33.84 43.94,33.84 46.74,36.64 46.74,40.88 48.69,42.83 48.69,45.25 50.06,46.62 51.66,46.62 52.31,47.26 52.31,49.69 54,51.38 v2(54,51.72) ; v2(20.09,73.64) 20.09,74.74 21.72,76.36 22.66,76.36 23.85,77.56 28.37,77.56 29.49,76.44 34.68,76.44 v2(35.35,77.1)
  IN3 w0.508: v2(54,51.72) 54,52.79 55.05,53.84 55.05,58.59 57.24,60.78 60.13,60.78 61.92,58.99 61.92,58.95 v2(62.06,58.81)
  BOTTOM w0.508: v2(62.06,58.81) 61.7,59.17 PR223.1
  vias: v2(20.39,17.46) v2(20.38,16.79) v2(20.92,19.18) v2(21.01,17.14) v2(21.51,19.2) v2(21.62,17.13) v2(36.36,78.75) v2(36.67,78.23) v2(36.94,78.76) v2(36.98,77.71) v2(37.29,78.21) v2(37.54,78.76) v3(47.42,24.01) v4(48.24,24.06) v4(48.9,24.67) v4(48.87,24.04) v4(49.51,24.04) v4(49.56,24.67)
+TPM_LPM: length 9.5
  TOP w0.203: v2(184.86,41.33) 184.47,40.94 184.15,40.94 183.5,40.3 182.77,40.3 182.6,40.47 C98.1 CA72.1 182.6,43.45 182.73,43.57 U15.8
  BOTTOM w0.203: RC229.2 RC228.2 185.01,42.83 v3(184.73,42.55) 184.73,41.46 v2(184.86,41.33)
+V_DDR_REF_CA: length 19.9
  TOP w0.508: v2(105.27,42.3) 105.27,42.9 104.65,43.52 CD185.1 RD111.1
  IN2 w0.508: v2(105.27,42.3) 106.83,42.3 108.54,44 108.54,46.14 110.41,48.01 110.41,50.73 110.9,51.22 111.33,51.22 111.9,51.79 112.93,51.79 113.14,51.57 113.99,51.57 v2(114.26,51.84)
  BOTTOM w0.305: v2(114.26,51.84) 114.18,51.76 114.18,51.38 113.9,51.1 UCPU1.AY67
+V_DDR_REFA_R: length 23.2
  TOP w0.508: v2(102.01,40.75) 102.92,41.66 103.92,41.66 105.26,40.32 CD186.1 RD113.1
  IN2 w0.508: v2(102.01,40.75) 102.29,41.03 107.26,41.03 109.73,43.49 109.73,45.86 112.22,48.35 112.22,50.42 v2(112.56,50.75)
  BOTTOM w0.305: UCPU1.AY68 112.58,50.73 v2(112.56,50.75)
+V_DDR_REFB_R: length 57
  TOP w0.508: v2(140.44,40.14) 139.7,39.4 114.22,39.4 112.47,41.16 v2(110.74,41.16) ; v2(152.17,39.36) 152.34,39.2 CD187.1 RD114.1
  IN2 w0.508: v2(110.74,41.16) 110.74,45.37 113.27,47.9 v2(113.27,50.19)
  BOTTOM w0.305: UCPU1.BA67 113.76,50.19 v2(113.27,50.19)
  BOTTOM w0.508: v2(152.17,39.36) 151.45,38.64 v3(141.12,38.64) 140.64,38.64 140.11,39.18 140.11,39.81 v2(140.44,40.14)
+VCHGR:
  vias: v3(74.8,33.59) v4(68.3,30.69) v4(68.94,30.69) v4(70.03,30.65) v4(70.78,30.64) v4(71.95,30.66) v4(72.63,30.66) v4(73.53,32.11)
+VR_CAP: length 7.2
  TOP w0.127: UE5.B12 187.21,64.77 186.55,64.77 185.93,65.39 185.93,65.64 v2(185.95,65.64) ; CE45.1 189.84,65.75 189.5,65.75 189.23,65.48 v2(189.15,65.48)
  BOTTOM w0.127: v2(189.15,65.48) 189.15,65.14 189.02,65.02 186.55,65.02 185.95,65.61 v2(185.95,65.64)
+VREFCA: length 86.8
  TOP w0.254: UD19.H4 104.17,25.96 v2(103.84,26.29) ; UD21.H4 137.75,25.97 v2(138.08,26.3) ; v2(120.02,26.3) 119.76,26.04 119.76,25.97 UD20.H4 ; v2(153,26.3) 153.32,25.98 UD22.H4
  TOP w0.381: CD180.1 103.99,20.74 104.22,20.98 104.22,21.23 v2(104.24,21.24)
  TOP w0.457: v2(95.15,30.59) 93.8,30.59 93.12,31.28 93.12,32.1 92.15,33.07 92.15,33.9 93.19,34.93 95.58,34.93 99.34,38.69 99.34,42.55 100.33,43.54 RD17.2 100.58,43.52 RD19.1 RD111.2
  IN2 w0.508: v2(95.15,30.59) 96.98,28.76 96.98,27.19 98,26.16 98.57,26.16 98.78,26.37 100.1,26.37
  BOTTOM w0.508: 120.24,19.57 120.41,19.4 124.17,19.4 125.9,21.13 132.7,21.13 134.57,19.26 138.15,19.26 138.79,19.9 ; 120.24,19.57 120.02,19.34 115.32,19.34 114.28,20.38 114.28,21.8 ; 120.24,19.57 CD181.1 ; 138.79,19.9 139.29,19.39 153.26,19.39 153.9,20.02 CD184.1 153.9,21.22 154.1,21.42 154.1,22.18 153.47,22.82 152.5,22.82 151.69,23.63 151.69,25.81 152.18,26.3 v2(153,26.3) ; 138.79,19.9 CD183.1
  vias: v3(111.91,23.48)
+VREFDQ_A: length 37.5
  TOP w0.127: UD20.J11 120.34,31.42 v2(120.02,31.1)
  TOP w0.254: v2(104.5,31.9) 104.82,31.58 UD19.J11
  TOP w0.508: CD118.1 120.37,35.41 v2(120.83,35.87) ; v2(106.75,34.39) 105.88,34.39 105.33,34.93 CD117.1 105.33,36.41 103.48,38.26 RD25.1 103.51,38.46 RD21.2 RD113.2
  BOTTOM w0.508: v2(104.5,31.9) 104.94,31.9 105.89,32.85 105.89,33.54 v2(106.75,34.39) 105.99,35.14 105.99,36.74 106.91,37.65 v3(112.5,37.65) 116.08,37.65 117.7,36.03 120.67,36.03 v2(120.83,35.87) 121.33,35.37 121.33,34.12 121.51,33.93 121.51,32.97 120.02,31.47 v2(120.02,31.1)
+VREFDQ_B: length 30.7
  TOP w0.254: v2(138.73,31.9) 138.4,31.57 UD21.J11 ; v2(154.3,31.9) 153.97,31.57 153.97,31.5 UD22.J11
  TOP w0.508: RD22.2 RD114.2 153.9,38.29 RD26.1 153.9,35.48 CD120.1 v2(153.97,34.31) ; CD119.1 138.4,33.82 v2(138.44,33.79)
  BOTTOM w0.508: v2(154.3,31.9) 153.95,31.9 153.42,32.43 153.42,33.77 v2(153.97,34.31) 152.44,35.85 140.5,35.85 v3(139.62,34.97) v2(138.44,33.79) 137.85,33.2 137.85,32.46 138.41,31.9 v2(138.73,31.9)
-DCIN_JACK: length 6.6
  TOP w0.381: v3(23.41,74.45) 23.41,73.71 24.51,72.61 v2(24.51,72.26)
  TOP w0.406: PC105.2 23.41,76.71 v3(23.41,74.45)
  TOP w0.508: PC104.2 PC105.2
  vias: v2(24.47,71.68) v2(24.47,71.08) v2(25.11,72.27) v2(25.07,71.69) v2(25.07,71.09)
AC_DET: length 4.4
  TOP w0.127: PR215.1 22.15,78.78 21.82,79.11 21.05,79.11 v3(20.6,78.66)
  TOP w0.508: PR206.2 PR215.1
AC_DIS: length 265.9
  TOP w0.127: PQ302.2 36.92,23.02 PR301.1 35.85,23.02 35.41,22.58 35.41,22.23 35.26,22.08 33.17,22.08 v2(32.84,22.41) ; UE5.A50 179.36,57.82 179.36,57.64 178.75,57.02 177.41,57.02 v2(177.32,57.11) ; PR228.1 35.68,74.35 v2(35.35,74.69)
  IN1 w0.081: v2(35.35,74.69) 34.09,75.94 31.56,75.94 31.29,75.68 31.29,74.02 27.69,70.41 24.77,70.41 22.87,68.52 21.05,68.52 20.53,69.04 19.41,69.04 18.92,68.55 18.92,67.15 21.49,64.58 21.49,61.26 21.17,60.94 21.17,59.82 21.38,59.61 21.38,56.59 21.57,56.4 21.57,54.52 23.22,52.87 23.22,38.34 24.22,37.33 27.48,37.33 28.42,38.27 29.87,38.27 32.89,35.25 32.89,33.2 33.89,32.19 33.89,26.15 34.39,25.65 34.39,23.68 33.12,22.41 v2(32.84,22.41)
  IN2 w0.089: v2(44.4,66.81) 44.4,66.71 43.26,65.57 39.09,65.57 36.78,67.88 36.78,73.25 v2(35.35,74.69)
  IN3 w0.089: v2(170.66,73.11) 171.16,73.61 171.16,76.49 169.45,78.2 155.61,78.2 155.52,78.29 151.87,78.29 151,79.16 129.15,79.16 129.05,79.05 92.91,79.05 90.07,76.21 84.09,76.21 83.63,75.75 80.28,75.75 79.22,76.82 70.91,76.82 68.77,78.96 62.97,78.96 62.79,79.14 61.98,79.14 61.75,78.92 57.78,78.92 52.76,73.9 52.76,72.22 52.53,71.99 52.1,71.99 51.08,70.98 51.08,69.76 48.6,67.28 44.87,67.28 v2(44.4,66.81)
  IN4 w0.081: 171.66,72.02 170.66,73.02 v2(170.66,73.11) ; v2(177.32,57.11) 177.29,57.11 177.17,57.24 177.17,58.61 176.26,59.52 176.1,59.52
  IN4 w0.089: 176.1,59.52 175.03,59.52 174.4,60.15 174.4,61.49 173.23,62.66 173.23,64.27 173.14,64.36 173.14,66.4 173.6,66.86 173.6,68.02 172.96,68.65 172.96,71.36 172.3,72.02 171.66,72.02
AC_PRESENT: length 61.8
  TOP w0.127: UE5.A54 181.36,57.41 v2(180.84,56.89) ; RC243.1 144.58,47.79 144.58,47.89 144.2,48.27 v2(143.99,48.27)
  IN3 w0.089: v2(180.84,56.89) 180.84,56.89 178.6,56.89 175.65,53.95 173.49,53.95 172.64,53.09 171.54,53.09 171.21,53.43 168.91,53.43 164.7,49.22 161.25,49.22 160.32,48.28 159.88,48.28 154.56,42.96 151.46,42.96 151.19,42.69 144.31,42.69 139.52,47.48 139.52,48.4 140.03,48.9 141.17,48.9 141.68,48.4 142.89,48.4 143.19,48.09 143.82,48.09 v2(143.99,48.27)
  BOTTOM w0.076: UCPU1.AY15 143.25,50.53 143.25,50.25 143.14,50.14 143.14,48.31 143.45,48 143.72,48 v2(143.99,48.27)
ACAV_IN: length 202.4
  TOP w0.127: v3(187.09,56.81) 186.89,57.01 186.32,57.01 186.32,57.02 v2(186.33,57.02) 186.36,57.05 UE5.A64
  IN1 w0.081: v2(41.9,21.34) 41.9,20.75 43.1,19.54 43.1,18.02 43.35,17.78 43.35,17.04 43.7,16.68 46.7,16.68 47.32,17.31 48.49,17.31 49.66,18.48 53.42,18.48 55.17,20.23 62.22,20.23 64.85,17.6 67.17,17.6 69.53,19.96 71.61,19.96 76.26,24.61 78.48,24.61 79.02,24.07 89.33,24.07 89.97,23.43 89.97,22.79 91.2,21.56 91.2,18.36 91.63,17.94 92.41,17.94 93.17,18.7 94.53,18.7 94.78,18.96 101.15,18.96 102.74,17.37 111.31,17.37 111.76,16.91 115.75,16.91 116.94,15.72 125.63,15.72 127.13,17.21 131.6,17.21 133.78,15.04 151.33,15.04 152.7,16.41 157.32,16.41 159.1,18.19 161.74,18.19 163.11,19.55 171.91,19.55 173.17,20.81 173.17,33.12 171.91,34.39 171.91,36.58 171.46,37.03 171.46,38.08 172.57,39.19 172.57,42.81 172.97,43.21 172.97,44.87 174.59,46.48 174.59,47.15 176.82,49.38 177.16,49.38 178.1,50.33 178.1,52.55 179.28,53.73 179.28,55.37 178.94,55.71 178.94,56.34 179.93,57.33 181.04,57.33 182.72,55.65 184.74,55.65 186.1,57.01 186.32,57.01 186.32,57.02 v2(186.33,57.02)
  BOTTOM w0.127: v2(41.9,21.34) 41.9,21.86 PR314.1
ACAV_IN_NB: length 6.5
  TOP w0.127: v2(185.47,67.24) 185.61,67.38 185.61,67.87 UE5.B20
  BOTTOM w0.127: DE11.2 188.13,69.83 RE102.2 187.82,68.74 186.57,68.74 185.47,67.64 v2(185.47,67.24) 184.86,66.62 v3(184.86,66.39)
ALW_PWRGD_3V_5V: length 120.4
  TOP w0.381: PR277.1 59.3,32.68 59.61,32.38 63.69,32.38 67.87,36.55 v2(67.87,37.55) ; v2(56.93,56.33) 57.78,56.33 58.14,55.97 PR280.2
  TOP w0.508: v2(83.54,27.52) 83.54,26.93 80.98,24.37 79.17,24.37 78.46,25.08 75.06,25.08 73.1,23.12 73.1,19.33 74.75,17.69 86.54,17.69 v2(87.71,16.52)
  IN1 w0.508: v2(67.87,37.55) 69.77,35.65 72.01,35.65 74.35,33.31 79.27,33.31 79.63,32.95 v2(79.63,32.67)
  IN2 w0.406: v2(50.02,41.19) 49.42,41.19 49.02,41.59 49.02,45.58 50.17,46.72 51.94,46.72 52.49,47.27 52.49,50.08 53.39,50.99 53.39,51.95 53.75,52.31 54.51,52.31 56.72,54.52 56.72,55.46 56.93,55.67 v2(56.93,56.33)
  IN2 w0.508: v2(87.71,16.52) 86.72,17.51 86.72,19.34 87.48,20.1 91.59,20.1 v2(92.15,19.54) ; v2(83.54,27.52) 83.54,28.43 79.63,32.34 v2(79.63,32.67)
  IN4 w0.508: v2(67.87,37.55) 66.88,36.56 64.53,36.56 63.29,37.8 61.32,37.8 58.9,40.22 51,40.22 50.02,41.2 v2(50.02,41.19)
  BOTTOM w0.203: PU500.9 91.77,20.31 92.02,20.06 92.02,19.92 92.15,19.8 v2(92.15,19.54)
  BOTTOM w0.508: PR506.1 67.87,37.65 v2(67.87,37.55) ; v2(87.71,16.52) 88.21,17.03 PR502.2
ALWON: length 182.5
  TOP w0.127: v2(184.46,57.03) 184.36,57.13 UE5.A60 ; v2(92.15,18.55) 93.56,18.55 94.92,19.91 94.92,23.68 94.11,24.49 89.69,24.49 88.77,25.41 85.91,25.41 v2(85.42,24.93)
  IN1 w0.081: v2(78.87,32.67) 78.65,32.89 74.17,32.89 71.83,35.22 66.73,35.22 v2(64.46,37.5)
  IN1 w0.089: v2(92.15,18.55) 92.74,19.14 94.36,19.14 94.7,19.48 101.23,19.48 102.92,17.8 111.48,17.8 111.94,17.34 115.93,17.34 117.12,16.15 125.45,16.15 126.95,17.65 131.78,17.65 133.96,15.46 151.16,15.46 152.53,16.84 157.12,16.84 158.92,18.63 161.57,18.63 162.93,19.98 171.74,19.98 172.75,20.99 172.75,32.94 170.54,35.15 170.54,36.76 170.99,37.22 170.99,38.22 172.14,39.36 172.14,42.99 172.54,43.39 172.54,45.04 174.16,46.66 174.16,47.33 175.97,49.14 175.97,50.57 176.66,51.26 177.31,51.26 177.56,51.51 177.56,52.61 178.86,53.91 178.86,55.17 178.51,55.52 178.51,56.65 179.69,57.82 181.15,57.82 182.89,56.08 183.5,56.08 v2(184.46,57.03)
  IN2 w0.089: v2(85.42,24.93) 82.88,27.47 82.88,28.41 78.87,32.42 v2(78.87,32.67)
  BOTTOM w0.127: v2(92.15,18.55) 92.15,17.9 91.28,17.03 PR503.1
  BOTTOM w0.203: v2(64.46,37.5) 64.49,37.53 PR510.1
AUD_PWR_EN: length 214.3
  TOP w0.127: U664.5 32.72,43.49 32.54,43.67 32.54,44.1 v2(32.64,44.19) ; U664.3 33.52,43.66 v2(33.63,43.77) ; v3(37.43,37.51) 37.72,37.22 v2(37.72,36.99) ; v2(53.7,21.79) 53.75,21.74 R1141.1 R1140.1 53.67,20.15 53.27,20.55 U719.5
  IN4 w0.081: v2(53.7,21.79) 53.72,21.82 ; 53.72,21.82 53.8,21.89 53.8,22.54 52.83,23.5 51,23.5 50.88,23.38 45.11,23.38 41.03,27.46 41.03,31.54 40.88,31.69 40.88,32.86 40.39,33.36 39.15,33.36 38.54,33.98 38.54,34.42 37.38,35.58 37.38,36.65 v2(37.72,36.99) ; 53.72,21.82 56.8,21.82 59.3,19.31 61.85,19.31 63.89,21.36 66.02,21.36 69.12,24.46 69.12,25.65 71.57,28.1 74.03,28.1 76.85,30.92 77.7,30.92 78.8,32.02 82.57,32.02 84.03,33.48 84.03,33.48 84.39,33.84 85.63,33.84 85.96,34.17 85.96,34.79 86.55,35.38 90,35.38 90.81,34.57 95.54,34.57 96.61,33.5 96.61,30.08 97.43,29.26 97.43,25.54 97.52,25.45 97.52,23.26 97.84,22.94 99.68,22.94 100.85,21.77 105.85,21.77 107.2,20.41 123.6,20.41 124,20.01 144.57,20.01 145.07,20.51 147.57,20.51 147.98,20.11 160.6,20.11 163.46,22.97 163.46,26.05 162.06,27.44 162.06,28.3 163.73,29.97 163.73,33.41 163,34.14 162.31,34.14 160.44,36.01 160.44,37.42 156.71,41.15 156.71,43.61 155.73,44.59 155.73,45.4 154.82,46.31 154.82,46.99 154.04,47.77 v2(154.04,47.8)
  BOTTOM w0.076: UCPU1.BA7 148.72,50.03 148.72,49.84 148.87,49.69 149.17,49.69 150.09,48.78 150.34,48.78 150.93,48.19
  BOTTOM w0.127: 150.93,48.19 153.65,48.19 v2(154.04,47.8) ; v2(37.72,36.99) 36.78,36.99 36.35,37.42 35.33,37.42 34.6,38.16 34.6,42.21 33.63,43.18 v2(33.63,43.77) 33.63,43.86 33.29,44.19 v2(32.64,44.19)
AUDIO_VREF: length 2.7
  TOP w0.203: UA2.28 23.99,30.68 23.67,31 v2(23.44,31) 23.25,31 23.05,31.2 CA87.1
AUX_EN_WOWL: length 201.9
  TOP w0.127: QE14.2 34.85,34.58 35.47,35.2 35.47,36.38 36.09,36.99 36.81,36.99 37.22,36.57 38.04,36.57 38.25,36.79 38.25,37.32 v2(38.58,37.65) 38.05,38.19 37.68,38.19 37.31,38.56 37.31,39.4 R1186.2 36.33,40.39 36.33,40.89 36.53,41.1 U720.3 ; v2(178.74,65.57) 178.53,65.77 178.01,65.77 UE5.B38
  IN2 w0.089: v2(38.58,37.65) 38.58,39.38 39.35,40.14 39.35,46.62 40.07,47.34 40.07,49.24 41.1,50.27 41.1,51.36 42.27,52.53 42.27,53.21 42.98,53.93 42.98,55.05 43.36,55.43 45.83,55.43 47.26,56.86 47.26,66.12 50.94,69.8 50.94,70.52 53.15,72.73 53.15,73.82 57.92,78.58 58.89,78.58 v2(59.84,79.54)
  IN3 w0.089: v2(59.84,79.54) 59.84,79.63 60.26,80.04 69.89,80.04 71.3,78.63 72.26,78.63 72.44,78.81 73.24,78.81 73.58,78.46 76.15,78.46 77.15,77.47 79.48,77.47 80.55,76.4 83.37,76.4 84.44,77.48 89.2,77.48 89.95,78.24 89.95,78.51 91.21,79.76 151.3,79.76 152.09,78.98 155.6,78.98 155.84,79.22 172.25,79.22 177.86,73.61 179.17,73.61 v2(179.74,74.19)
  IN4 w0.089: v2(178.74,65.57) 178.32,65.99 178.32,68.96 177.91,69.37 177.91,71.13 177.71,71.32 177.71,72.05 179.74,74.09 v2(179.74,74.19)
B+: length 101.9
  TOP w0.254: v2(168.69,62.16) 168.53,62.16 168.18,61.81 PR409.1 ; PR402.1 167.95,64.75 v2(167.35,65.35)
  TOP w0.381: v2(56.52,51.77) 56.24,51.77 55.6,52.41 55.3,52.41 PQ204.3 54.76,54.44 PR201.1 ; C614.1 197.21,51.14 v2(197.71,51.65) ; v2(159.59,42.6) 159.04,42.06 R78.1 ; C615.1 196.89,52.54 v2(196.95,52.47)
  TOP w0.508: PL1402.1 v5(203.83,80.14)
  IN1 w0.381: v2(163.22,35.57) 163.22,36.33 162.36,37.19 162.36,40.47 160.22,42.6 v2(159.59,42.6)
  IN1 w0.508: v5(203.83,80.14) 202.08,78.39 198.83,78.39 198.01,79.21 197.45,79.21 195.94,80.72 188.5,80.72 185.76,77.97 179.9,77.97 v2(177.8,80.07)
  IN3 w0.762: 198.9,72.83 199.2,73.12 200.27,73.12 200.81,72.58 201.89,72.58 202.65,73.34 202.65,78.96 v5(203.83,80.14)
  BOTTOM w0.254: v2(167.35,65.35) 167.73,64.97 167.73,63.13 v2(168.69,62.16) 169.1,61.75 169.1,55.21 169.47,54.84 170.17,54.84 172.07,52.94 178.93,52.94 179.95,51.91 v2(179.95,51.33)
  BOTTOM w0.381: v2(189.84,48.35) 190.15,48.35 190.41,48.09 C616.1
  BOTTOM w0.508: v2(190.4,50) 190.35,50.05 C617.1 ; v2(197.76,66.76) 197.11,66.76 PL700.1 197,67.48 v2(197.82,67.48) ; v2(66.02,37.58) 66.27,37.83 PR508.1 ; v2(173.25,35.85) 172.18,34.78 170.41,34.78 169.39,33.77 164.74,33.77 163.22,35.29 v2(163.22,35.57)
  vias: v2(58.24,54.43) v2(58.83,54.42) v2(59.44,55.5) v2(59.45,54.87) v2(59.47,54.18) v2(59.47,53.48) v2(59.47,52.81) v2(70.08,41.36) v2(70.08,40.73) v2(70.71,41.36) v2(70.71,40.73) v2(70.71,40.09) v2(70.71,39.33) v2(71.35,41.36) v2(71.35,40.73) v2(71.35,40.09) v2(71.35,39.33) v2(71.35,37.8) v2(71.35,37.17) v2(71.98,37.8) v2(71.98,37.17) v2(72.11,39.96) v2(72.11,39.33) v2(80.37,33.36) v2(80.37,32.76) v2(92.74,26.7) v2(92.76,27.86) v2(92.77,27.28) v2(93.35,27.87) v2(93.33,26.71) v2(93.33,17) v2(93.36,27.29) v2(93.57,17.64) v2(93.92,17.13) v2(94.5,17.64) v2(95.09,17.64) v2(95.7,17.64) v2(159.89,16.9) v2(160.16,16.36) v2(160.47,16.9) v2(161.01,16.34) v2(161.15,16.91) v2(163.12,17.87) v2(172.95,17.48) v2(173.15,37.63) v2(173.25,36.45) v2(173.26,37.05) v2(173.58,17.48) v2(174.39,36.99) v2(176.35,21.97) v2(176.35,21.33) v2(179.94,50.71) v2(195.25,17.71) v2(195.25,17.13) v3(195.45,16.09)
B+_1.0V: length 1.7
  TOP w0.508: PC705.1 196.08,63.8 PC702.1
  vias: v2(194.31,64.02) v2(194.31,63.43) v3(194.96,64.4)
B+_3V:
  vias: v2(89.53,23.11) v2(90.45,23.15) v2(91.88,23.98) v2(92.18,23.48) v2(93.9,24.04) v2(93.91,23.45) v3(90.91,23.83)
B+_5V:
  vias: v2(63.35,44.92) v2(66.02,43.62) v2(66.61,43.62) v2(67.2,43.62) v2(67.97,43.63) v2(68.56,43.62) v2(69.15,43.63) v3(65.15,45.17)
BAT1_LED#: length 187.3
  TOP w0.127: UE5.A40 177.16,63.52 176.63,63.52 176.5,63.39 v2(176.5,63.37) ; RE104.2 174.3,60.86 v2(175.63,60.86)
  IN1 w0.081: v2(43.24,21.86) 42.94,21.56 42.94,20.9 43.87,19.97 48.42,19.97 50.88,22.43 50.88,23.23 51.25,23.6 55.07,23.6 56.25,22.41 63.04,22.41 63.89,21.57 67.23,21.57 67.99,22.32 71.54,22.32 76.5,27.29 82.88,27.29 83.52,26.64 91.31,26.64 91.93,26.03 92.47,26.03 94.93,23.57 94.93,23 96.94,20.98 102.76,20.98 103.12,20.62 109.94,20.62 110.15,20.42 110.99,20.42 112.3,19.11 117.2,19.11 118,18.31 125.48,18.31 126.31,19.14 132.42,19.14 133.51,18.04 147.08,18.04 147.42,18.38 156.49,18.38 158.22,20.1 160.9,20.1 163.68,22.88 163.68,25.13 166.31,27.76 166.31,31.97 166.17,32.12 166.17,35.84 166.07,35.94 166.07,37.51 166.52,37.96 166.52,40.01 167.17,40.66 168.78,40.66 169.65,41.52 169.65,44.28 172.57,47.2 172.57,52.05 174.91,54.4 174.91,54.82 175.5,55.4 175.5,57.71 175.15,58.06 175.15,59.38 175.36,59.6 175.36,60.59 v2(175.63,60.86)
  IN2 w0.089: v2(176.5,63.37) 176.5,63.33 177.2,62.64 177.2,61.16 176.54,60.51 175.98,60.51 v2(175.63,60.86)
  BOTTOM w0.127: JKB1.10 42.42,21.14 43.13,21.86 v2(43.24,21.86)
BAT2_LED#: length 184.7
  TOP w0.127: v2(178.66,63.13) 178.52,63.27 178.01,63.27 UE5.B43
  IN1 w0.081: v2(178.66,63.13) 178.4,63.13 177.32,62.04 174.8,62.04 174.65,61.89 174.65,60.9 174.52,60.77 174.52,58.39 175.28,57.63 175.28,55.48 174.71,54.91 174.71,54.53 172.35,52.18 172.35,48.24 169.44,45.33 169.44,41.61 168.7,40.87 167.08,40.87 166.31,40.09 166.31,38.08 165.31,37.09 165.31,34.17 165.16,34.02 165.16,26.91 163.47,25.22 163.47,22.97 160.81,20.31 158.13,20.31 156.41,18.59 147.33,18.59 147,18.25 133.61,18.25 132.51,19.35 126.21,19.35 125.65,18.78 117.84,18.78 117.29,19.33 112.39,19.33 111.08,20.63 110.24,20.63 110.03,20.84 103.24,20.84 102.88,21.19 97.94,21.19 95.89,23.25 95.5,23.25 95.17,23.59 95.17,23.63 91.94,26.85 83.62,26.85 82.98,27.49 75.95,27.49 v2(71.65,23.2) 71.65,22.79 71.4,22.54 67.9,22.54 67.14,21.78 63.98,21.78 63.13,22.63 56.34,22.63 55.16,23.81 51.07,23.81 50.66,23.4 50.66,22.5 48.34,20.18 43.96,20.18 43.36,20.79 v2(43.36,21.25)
  BOTTOM w0.127: RE105.2 178.61,63.08 v2(178.66,63.13) ; JKB1.9 42.92,20.82 v2(43.36,21.25)
BAT_LED#_LV1: length 12.9
  TOP w0.127: LED12.1 v2(3.13,15.6) ; R910.2 4.76,5.41 v2(4.49,5.41)
  BOTTOM w0.127: v2(4.49,5.41) 4.49,14.24 v2(3.13,15.6)
BAT_LED#_LV2: length 4.6
  TOP w0.127: LED14.1 3.17,12 v3(3.93,11.25) 5.28,9.89 R911.2
BAT_LED#_LV3: length 3.4
  TOP w0.127: LED10.1 2.19,8.59 v3(3.81,8.59) R912.2
BAT_LED#_LV4: length 4.5
  TOP w0.127: R913.2 5.06,7.71 v3(3.9,6.55) 2.15,4.8 LED11.1
BAT_LED#_LV5: length 7.3
  TOP w0.127: LED13.1 2.55,1.2 3.66,2.31 v3(3.66,4.35) 3.66,5.19 R916.2
BATBTN#: length 245.1
  TOP w0.203: UE5.A63 185.86,56.83 186.26,56.44 v2(186.45,56.44) 186.72,56.44 186.87,56.29 189.48,56.29 190.7,57.51 RPE5.4
  IN1 w0.508: v2(180.5,55.67) 179.71,54.88 179.71,53.55 178.59,52.44 178.59,49.87 176.76,48.05 176.76,47.83 174.79,45.87 174.79,45.24 174.01,44.46 173.86,44.46 173.46,44.05 173.46,43.24 173.7,43 173.7,39.72 171.88,37.9 171.88,37.21 172.33,36.76 172.33,34.57 173.6,33.3 173.6,26.68 175.08,25.2 175.08,21.75 174.57,21.24 174.57,20.44 172,17.87 168.88,17.87 168.12,17.1 166.5,17.1 164.48,19.13 163.28,19.13 161.92,17.77 159.3,17.77 157.34,15.81 152.7,15.81 151.5,14.61 133.6,14.61 131.42,16.79 127.31,16.79 125.81,15.3 116.76,15.3 115.83,16.23 111.84,16.23 111.13,16.94 108.65,16.94 107.93,16.23 102.74,16.23 101.07,17.91 96.3,17.91 95.93,18.28 93.35,18.28 92.54,17.48 91.49,17.48 85.64,23.32 79.33,23.32 78.79,22.78 78.79,20.74 77.14,19.09 69.26,19.09 67.35,17.18 65.52,17.18 65.52,17.18 60.34,17.18 59.95,17.56 58.67,17.56 57.45,16.34 54.95,16.34 54.63,16.67 50.41,16.67 49.32,15.59 43.16,15.59 42.12,16.63 39,16.63 38.78,16.41 37.45,16.41 36.48,17.38 22.89,17.38 20.57,15.07 17.2,15.07 14.92,12.8 10.95,12.8 7.26,16.49 7.26,17.55 5.55,19.26 v2(5.06,19.26)
  IN4 w0.381: v2(186.45,56.44) 185.7,55.69 183.41,55.69 183.06,55.34 180.84,55.34 v2(180.5,55.67)
  vias: v3(5.11,18.6)
BATDRV#: length 46.8
  IN3 w0.508: v2(50.5,37.45) 49.43,38.52 41.17,38.52 40.59,37.93 40.59,37.17 40.87,36.89 v2(41.12,36.89)
  IN4 w0.406: v2(50.5,37.45) 50.5,37.55 51.21,38.26 52.96,38.26 54.25,36.97 58.46,36.97 58.83,36.61 63.65,36.61 64.29,35.98 69.9,35.98 71.78,34.1 77.2,34.1 v2(78.09,34.98)
  BOTTOM w0.381: PR323.2 41.63,35.8 41.12,36.31 v2(41.12,36.89)
  BOTTOM w0.406: PQ305.4 v2(78.09,34.98)
BATT_LED#_LV1: length 39.9
  TOP w0.127: v2(10.11,6.98) 9.73,6.6 Q41.3
  IN3 w0.089: v2(10.11,6.98) 7.3,6.98 6.01,8.28 6.01,10.63 7.79,12.4 10.39,12.4 11.11,13.13 14.88,13.13 16.89,15.13 23.26,15.13 24.17,16.04 33.62,16.04 v2(34.32,15.34)
  BOTTOM w0.127: v2(34.32,15.34) 33.94,14.97 UE4.25
BATT_LED#_LV2: length 30.3
  TOP w0.127: v2(8.28,10.17) QH9.1
  IN3 w0.089: v2(32.98,15.32) 32.47,15.83 24.26,15.83 23.35,14.92 16.98,14.92 14.97,12.91 11.28,12.91 8.53,10.17 v2(8.28,10.17)
  BOTTOM w0.127: v1(33.06,13.29) 33.29,13.52 UE4.26 33.29,15.01 v2(32.98,15.32)
BATT_LED#_LV3: length 32.4
  TOP w0.127: v2(7.75,9.89) 7.75,11.26 7.54,11.47 QH9.4 ; v2(32.64,13.7) v1(33.47,13.7)
  IN3 w0.089: v2(32.64,13.7) 32.64,14.51 31.61,15.54 25.79,15.54 24.5,14.25 24.31,14.25 24.3,14.24 23.96,14.24 23.95,14.25 18.08,14.25 16.52,12.7 11.38,12.7 8.36,9.67 7.96,9.67 v2(7.75,9.89)
  BOTTOM w0.127: UE4.27 v2(32.64,13.7)
BATT_LED#_LV4: length 31.9
  TOP w0.127: v2(9.72,8.1) 9.68,8.1 9.33,7.75 QH8.1
  IN3 w0.089: v2(31.99,13.7) 31.99,14.81 31.47,15.33 25.88,15.33 23.53,12.98 17.11,12.98 16.61,12.48 11.49,12.48 7.99,8.98 7.99,8.67 8.26,8.4 9.41,8.4 v2(9.72,8.1)
  BOTTOM w0.127: UE4.28 v2(31.99,13.7)
BATT_LED#_LV5: length 27.6
  TOP w0.127: v2(8.41,8.82) 8.18,9.05 QH8.4
  IN3 w0.089: v2(8.41,8.82) 8.41,9.06 11.6,12.25 16.74,12.25 17.25,12.76 23.62,12.76 24.7,13.84 30.35,13.84 31.13,14.62 v2(31.13,14.69)
  BOTTOM w0.127: v2(31.13,14.69) 30.96,14.86 UE4.1
BATT_PRS: length 9.9
  TOP w0.127: PRP100.8 67.16,19.29 67.54,19.67 67.54,22.06 v2(66.5,23.1) v3(65.71,23.89)
  BOTTOM w0.127: v2(66.5,23.1) 66.27,23.33 65.51,23.33 65.1,23.73 65.1,26.14 JBATT1.5
BATT_VREF: length 12.2
  TOP w0.127: v2(164.97,59.06) 164.38,58.47 164.38,58.47 ; 164.38,58.47 PC407.1 ; 164.38,58.47 164.38,59.12 164.5,59.24 PU400.2 ; PU400.6 165.15,62.05 164.41,61.31 v2(164.34,61.31)
  BOTTOM w0.127: v2(164.97,59.06) 164.97,59.32 165.63,59.98 PR413.1 PR410.2 166.13,60.45 165.41,60.45 165.33,60.37 164.84,60.37 164.54,60.66 164.54,61.11 v2(164.34,61.31) 164.85,61.31 v3(165.35,61.82)
BC_CLK_ECE1117: length 195.4
  TOP w0.127: v2(184.81,69.43) 184.81,69.38 184.86,69.33 184.86,68.72 UE5.A20 ; v3(43.83,21.55) 43.99,21.71 v2(44.52,21.71)
  IN1 w0.081: v2(44.52,21.71) 44.52,21.48 45.18,20.82 48.03,20.82 50.03,22.82 50.03,23.66 50.81,24.44 58.29,24.44 60.14,26.29 63.24,26.29 63.95,27 72.87,27 76.62,30.74 81.59,30.74 83.88,33.03 87.85,33.03 88.19,32.69 90.25,32.69 91.85,31.09 92.26,31.09 96.66,26.68 96.66,23.65 98.09,22.23 102.66,22.23 102.9,22.46 110.8,22.46 112.84,20.42 117.75,20.42 118.55,19.61 125.29,19.61 125.86,20.18 155.75,20.18 164.06,28.49 164.06,33.73 163.87,33.91 163.87,36.94 164.06,37.12 164.06,39.29 163.79,39.56 163.79,40.21 164.63,41.05 164.8,41.05 165.08,41.05 168.79,44.76 168.79,45.58 171.71,48.5 171.71,52.44 174.06,54.79 174.06,56.74 174.41,57.08 174.41,57.62 173.9,58.13 173.9,61.03 174,61.13 174,62.12 174.54,62.66 177.01,62.66 177.65,63.31 177.65,64.2 178.56,65.12 180.17,65.12 180.36,64.92 183.4,64.92 184.81,66.34 v2(184.81,69.43)
  BOTTOM w0.127: v2(44.52,21.71) 44.17,21.71 43.79,21.33 43.79,21.06 43.42,20.7 JKB1.8
BC_DAT_ECE1117: length 219.5
  TOP w0.127: v2(185.7,66.43) 185.69,66.42 185.44,66.42 185.02,66.84 185.02,67.37 185.11,67.46 UE5.B21 ; v3(47.02,15.46) 45.94,15.46 v2(44.11,17.29) ; RPE5.1 190.68,59.01 v2(190.05,59.65)
  IN1 w0.089: v2(44.11,17.29) 44.32,17.5 47.21,17.5 47.23,17.52 48.4,17.52 49.57,18.69 53.33,18.69 55.09,20.44 62.32,20.44 64.95,17.81 67.08,17.81 69.44,20.18 71.52,20.18 76.17,24.82 78.57,24.82 79.11,24.28 89.88,24.28 91.03,23.13 91.03,22.03 91.42,21.65 91.42,18.45 91.71,18.15 92.32,18.15 93.09,18.92 94.45,18.92 94.7,19.17 101.24,19.17 102.83,17.58 111.4,17.58 111.85,17.13 115.84,17.13 117.03,15.93 125.54,15.93 127.03,17.43 131.69,17.43 133.87,15.25 151.25,15.25 152.62,16.62 157.22,16.62 159.01,18.4 161.65,18.4 163.02,19.77 171.83,19.77 172.96,20.9 172.96,33.03 170.92,35.07 170.92,36.84 171.21,37.13 171.21,38.13 172.35,39.27 172.35,42.9 172.76,43.3 172.76,44.95 174.37,46.57 174.37,47.24 176.19,49.05 176.19,50.48 176.75,51.04 177.4,51.04 177.78,51.42 177.78,52.52 179.07,53.82 179.07,55.29 178.73,55.63 178.73,56.43 179.84,57.54 181.13,57.54 182.8,55.86 184.46,55.86 186.32,57.72 188.12,57.72 v2(190.05,59.65)
  IN4 w0.089: v2(185.7,66.43) 186,66.73 186.25,66.73 186.43,66.56 186.76,66.56 186.76,66.56 187.54,65.78 187.54,64.69 189.15,63.08 189.15,61.8 189.46,61.5 189.46,60.58 190.05,59.99 v2(190.05,59.65)
  BOTTOM w0.127: v2(44.11,17.29) 43.46,17.94 43.46,19.49 43.92,19.95 JKB1.7
BC_INT#_ECE1117: length 196.4
  TOP w0.127: v2(44.22,21.14) 44.22,19.55 v3(43.87,19.21) ; UE5.A19 185.36,69.34 v2(185.45,69.43)
  IN1 w0.081: v2(185.45,69.43) 185.06,69.05 185.06,66.26 183.52,64.72 180.28,64.72 180.08,64.91 178.65,64.91 177.86,64.12 177.86,63.19 177.13,62.46 174.63,62.46 174.21,62.04 174.21,61.05 174.11,60.95 174.11,58.22 174.63,57.69 174.63,57.01 174.27,56.65 174.27,54.69 171.92,52.34 171.92,48.42 169,45.5 169,44.68 165.17,40.84 164.72,40.84 164,40.12 164,39.65 164.27,39.38 164.27,37.04 164.08,36.85 164.08,34 164.27,33.81 164.27,28.34 155.9,19.97 125.95,19.97 125.38,19.4 118.47,19.4 117.66,20.21 112.76,20.21 110.72,22.25 103,22.25 102.76,22.01 98.01,22.01 96.45,23.56 96.45,26.6 92.17,30.88 91.76,30.88 90.17,32.47 88.11,32.47 87.76,32.82 83.97,32.82 81.68,30.53 76.71,30.53 72.96,26.78 64.04,26.78 63.33,26.07 60.22,26.07 58.21,24.06 55.5,24.06 55.33,24.23 50.9,24.23 50.24,23.57 50.24,22.68 48.17,20.61 44.74,20.61 44.22,21.13 v2(44.22,21.14)
  BOTTOM w0.127: v2(44.22,21.14) 44.42,20.93 44.42,20.36 JKB1.6
BEEP: length 244.7
  TOP w0.127: v2(32.54,44.77) 32.36,44.95 30.13,44.95 29.42,44.24 29.42,43.47 v1(26.79,40.85) 26.09,40.14 26.09,39.28 25.4,38.59 RA24.1 ; v2(186.06,67.24) 186.11,67.29 UE5.B19
  IN3 w0.089: v2(186.06,67.24) 185.66,66.84 185.54,66.84 184.38,65.68 184.38,64.83 183.08,63.53 183.08,60.94 182.74,60.59 182.74,58.08 183.45,57.37 183.45,55.98 182.19,54.71 181.33,54.71 180.63,54.01 179.08,54.01 177.49,52.42 177.49,51.53 177.22,51.26 176.79,51.26 176.26,50.73 176.26,45.72 179.07,42.91 180.23,42.91 180.67,42.46 180.67,40.2 179.81,39.34 174.29,39.34 174.01,39.61 171.15,39.61 170.52,38.99 166.43,38.99 165.9,38.46 163.75,38.46 163.57,38.46 163.22,38.11 162.87,38.11 162.2,37.45 162.2,34.66 163.16,33.7 163.16,32.28 162.64,31.76 162.46,31.76 160.53,29.83 160.53,28.88 159.45,27.79 159.45,26.13 158.95,25.63 158.95,23.85 155.83,20.74 135.22,20.74 134.42,21.54 133.32,21.54 133.22,21.45 125.17,21.45 124.51,22.11 118.19,22.11 116.73,20.64 105.58,20.64 104.35,21.88 98.9,21.88 96.74,24.04 96.74,33.16 95.26,34.63 90.07,34.63 89.87,34.83 87.69,34.83 84.79,37.73 84.79,39.89 85.22,40.32 85.22,40.81 84.97,41.06 84.58,41.06 84.48,41.16 84.48,41.54 82.37,43.65 70.91,43.65 68.39,46.17 65.55,46.17 64.67,47.05 62.9,47.05 v2(61.99,47.96)
  BOTTOM w0.127: v2(61.99,47.96) 62.33,48.3 62.33,49.23 61.63,49.93 54.2,49.93 53.77,50.37 52.56,50.37 51.74,49.55 51.74,48.76 51.17,48.19 51.17,46.7 51.43,46.44 51.43,45.44 52.13,44.74 52.13,42.67 51.59,42.13 50.76,42.13 50.24,42.65 48.08,42.65 46.78,43.95 43.96,43.95 42.67,42.65 39.36,42.65 37.24,44.78 34.56,44.78 34.47,44.69 32.63,44.69 v2(32.54,44.77)
