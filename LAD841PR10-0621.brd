# Allegro board LAD841PR10-0621.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_PTX_CARDRX_N6_C: length 1.9
  BOTTOM w0.127: CH14.2 205.87,19.72 205.87,18.78 205.71,18.62 JIO1.16
PCIE_PTX_CARDRX_P6: length 114.6
  IN2 w0.102: v2(140.34,74.02) 140.67,74.02 140.89,74.25 140.89,74.43 141.43,74.96 143.09,74.96 143.6,75.47 144.16,75.47 144.31,75.31 151.69,75.31 152.25,74.76 156.43,74.76 158.79,72.39 159.99,72.39 161.23,71.15 165.1,71.15 167.56,73.62 169.34,73.62 169.9,74.18 177.5,74.18 179.35,72.32 179.92,72.32 180.89,71.35 186.74,71.35 190.19,67.9 190.19,65.63 191.61,64.21 191.61,63.48 191.78,63.3 191.78,60.85 192.67,59.96 192.67,58.65 192.56,58.53 192.56,57.51 192.98,57.09 192.98,53.21 192.58,52.81 192.58,47.61 194.28,45.91 194.28,37.2 195.73,35.75 195.73,31.97 200.41,27.3 202.2,27.3 206.06,23.44 206.06,22.76 v2(206.32,22.49)
  BOTTOM w0.076: UCPU1.C20 140.6,72 140.77,72.17 140.77,73.19 140.73,73.23 140.73,73.63 v2(140.34,74.02)
  BOTTOM w0.127: v2(206.32,22.49) 206.21,22.49 206.09,22.37 206.09,21.19 206.24,21.04 CH13.1
PCIE_PTX_CARDRX_P6_C: length 1.9
  BOTTOM w0.127: JIO1.14 206.31,18.41 206.31,18.64 206.12,18.83 206.12,19.77 CH13.2
PCIE_PTX_SSDRX_N9: length 93.6
  IN4 w0.091: v2(137.92,73.5) 137.92,73.63 138.11,73.82 138.45,73.82 138.71,74.08 138.71,74.33 140.9,76.52 145.77,76.52 145.92,76.37 147.24,76.37 147.71,75.9 152.69,75.9 153.12,75.47 157.26,75.47 158.34,74.39 158.77,74.39 161.47,71.69 165.41,71.69 167.06,70.04 167.06,69.53 168.18,68.41 168.18,66.73 170.27,64.64 170.27,63.56 170.11,63.41 170.11,61.59 170.72,60.98 170.72,59.41 172.18,57.95 172.18,57.93 172.19,57.93 172.19,57.57 172.78,56.98 173.58,56.98 173.99,56.57 173.99,56.2 174.69,55.5 174.69,53.41 176.33,51.77 176.33,51.6 177.46,50.47 177.46,49.34 176.86,48.75 176.86,46.22 177.61,45.46 179.06,45.46 179.99,44.53 181.58,44.53 182.37,43.73 182.37,38.44 183.67,37.14 183.67,32.72 185.92,30.47 187.55,30.47 188.02,30 188.02,29.13 187.66,28.76 186.97,28.76 186.6,28.39 186.6,27.89 186.86,27.63 187.2,27.63 187.33,27.5 v2(187.33,27.36)
  BOTTOM w0.076: UCPU1.B23 138.68,71.84 138.62,71.9 138.39,71.9 138.22,72.07 138.22,72.79 138.39,72.95 138.39,73.46 138.18,73.67 138.09,73.67 v2(137.92,73.5)
  BOTTOM w0.127: v2(187.33,27.36) 187.17,27.52 186.92,27.52 CD39.1
PCIE_PTX_SSDRX_N9_C: length 4.2
  BOTTOM w0.127: CD39.2 185.44,27.57 185.25,27.57 185.06,27.38 185.06,26.19 184.79,25.92 v4(184.58,25.92) 184.25,25.92 184.13,25.79 183.15,25.79 JNGFF2.11
PCIE_PTX_SSDRX_N10: length 88.3
  IN4 w0.091: v2(187.4,29.3) 187.16,29.53 186.02,29.53 182.92,32.64 182.92,36.83 181.78,37.96 181.78,43.28 181.15,43.9 179.72,43.9 178.75,44.87 177.08,44.87 176.07,45.89 176.07,46.57 175.12,47.51 175.12,48.26 175.73,48.86 175.73,50.62 174.97,51.38 174.97,51.89 173.92,52.93 173.92,54.51 171.6,56.84 171.6,57.68 170.11,59.16 170.11,60.74 169.49,61.36 169.49,63.68 169.63,63.82 169.63,64.44 167.44,66.63 167.44,68.2 166.38,69.26 166.38,69.85 165.31,70.93 161.37,70.93 160.22,72.08 158.84,72.08 158.42,72.5 158.42,73.47 157.03,74.86 152.17,74.86 151.74,75.29 147.45,75.29 146.99,75.76 145.69,75.76 145.52,75.93 141.17,75.93 139.83,74.58 139.83,74.08 v2(139.26,73.51)
  BOTTOM w0.076: UCPU1.D23 138.93,70.62 138.93,70.82 138.97,70.96 138.97,71.07 139.03,71.27 139.05,71.35 139.1,71.5 139.11,71.52 139.11,71.55 139.11,71.8 139.08,71.89 139.08,71.89 139.08,72.08 139.1,72.14 139.11,72.17 139.11,72.54 138.95,72.7 138.95,73.2 v2(139.26,73.51)
  BOTTOM w0.127: CD45.1 186.98,29.48 187.21,29.48 v2(187.4,29.3)
PCIE_PTX_SSDRX_N10_C: length 3
  BOTTOM w0.127: JNGFF2.23 183.15,28.79 183.9,28.79 184.04,28.93 184.49,28.93 184.83,29.27 185.05,29.49 185.43,29.49 CD45.2
PCIE_PTX_SSDRX_N11: length 96.9
  IN4 w0.091: v2(136.5,74.38) 136.6,74.28 136.76,74.28 137.33,74.85 138.07,74.85 140.52,77.3 146.15,77.3 146.28,77.16 147.58,77.16 147.63,77.11 147.63,77.1 147.99,76.75 147.99,76.75 148.01,76.73 154.18,76.73 154.43,76.49 156.85,76.49 157.49,77.12 159.26,77.12 160.27,78.13 164.3,78.13 166.83,75.6 166.83,72.82 168.77,70.88 168.77,69.12 170.5,67.39 170.5,65.57 171.07,65 171.07,63.23 170.92,63.08 170.92,61.9 172.77,60.05 172.77,59.55 175.54,56.78 175.54,54.27 178.37,51.44 178.37,46.95 178.72,46.6 179.04,46.6 179.04,46.6 179.28,46.6 179.64,46.95 179.64,47.2 180.31,47.87 180.82,47.87 181.51,47.19 181.51,45.97 183.18,44.3 183.18,39.46 185.36,37.27 185.36,33.65 186.49,32.52 187.66,32.52 188.01,32.17 188.01,31.66 187.81,31.45 187.6,31.45 v2(187.4,31.25)
  BOTTOM w0.076: v2(136.5,74.38) 136.64,74.24 137.05,74.24 137.4,73.89 137.4,73.39 138.06,72.73 138.06,71.9 138.25,71.71 138.25,71.62 138.41,71.47 138.41,71.21 138.12,70.92 UCPU1.D24
  BOTTOM w0.127: CD53.1 186.98,31.39 187.27,31.39 v2(187.4,31.25)
PCIE_PTX_SSDRX_N11_C: length 3
  BOTTOM w0.127: CD53.2 185.43,31.39 184.76,31.39 184.26,31.89 183.93,31.89 183.83,31.79 JNGFF2.35
PCIE_PTX_SSDRX_P9: length 93.7
  IN4 w0.091: v2(137.92,74.18) 138.09,74.01 138.37,74.01 138.52,74.16 138.52,74.41 140.82,76.71 145.85,76.71 146,76.56 147.32,76.56 147.79,76.1 152.77,76.1 153.2,75.67 157.34,75.67 158.42,74.58 158.85,74.58 161.55,71.88 165.49,71.88 167.25,70.12 167.25,69.61 168.38,68.49 168.38,66.81 170.46,64.72 170.46,63.48 170.31,63.33 170.31,61.67 170.92,61.06 170.92,59.49 172.37,58.03 172.37,58.01 172.38,58.01 172.38,57.65 172.86,57.17 173.66,57.17 174.18,56.65 174.18,56.28 174.88,55.58 174.88,53.49 176.52,51.85 176.52,51.68 177.65,50.55 177.65,49.26 177.05,48.67 177.05,46.3 177.69,45.66 179.14,45.66 180.07,44.72 181.66,44.72 182.57,43.81 182.57,38.52 183.86,37.22 183.86,32.8 186,30.67 187.63,30.67 188.21,30.08 188.21,29.05 187.74,28.57 187.05,28.57 186.79,28.31 186.79,27.97 186.94,27.82 187.12,27.82 v2(187.33,28.03)
  BOTTOM w0.076: v2(137.92,74.18) 137.92,74.16 138.55,73.52 138.55,72.88 138.39,72.72 138.39,72.14 138.46,72.07 138.63,72.07 138.68,72.12 UCPU1.A23
  BOTTOM w0.127: CD43.1 186.67,27.95 186.84,27.78 187.08,27.78 v2(187.33,28.03)
PCIE_PTX_SSDRX_P9_C: length 4.2
  BOTTOM w0.127: JNGFF2.13 184.07,26.29 184.2,26.17 184.68,26.17 184.81,26.3 v4(184.81,27.27) 184.81,27.49 185.15,27.82 185.42,27.82 CD43.2
PCIE_PTX_SSDRX_P10: length 88.4
  IN4 w0.091: v2(139.26,74.14) 139.35,74.05 139.53,74.05 139.63,74.16 139.63,74.66 141.09,76.12 145.6,76.12 145.77,75.95 147.07,75.95 147.53,75.49 151.82,75.49 152.25,75.06 157.11,75.06 158.61,73.55 158.61,72.58 158.92,72.27 160.3,72.27 161.45,71.12 165.39,71.12 166.58,69.93 166.58,69.34 167.63,68.28 167.63,66.71 169.82,64.52 169.82,63.74 169.69,63.6 169.69,61.44 170.31,60.82 170.31,59.24 171.79,57.76 171.79,56.92 174.12,54.59 174.12,53.01 175.16,51.97 175.16,51.46 175.92,50.7 175.92,48.78 175.32,48.18 175.32,47.59 176.26,46.65 176.26,45.97 177.16,45.07 178.83,45.07 179.8,44.1 181.23,44.1 181.98,43.36 181.98,38.04 183.11,36.91 183.11,32.72 186.1,29.73 187.2,29.73 v2(187.4,29.93)
  BOTTOM w0.076: v2(139.26,74.14) 138.79,73.67 138.79,72.64 138.95,72.47 138.95,72.2 138.91,72.11 138.91,71.85 138.93,71.82 138.95,71.77 138.95,71.57 138.9,71.42 138.83,71.32 138.67,71.32 138.61,71.26 138.61,71.09 UCPU1.C23
  BOTTOM w0.127: CD46.1 186.99,29.74 187.21,29.74 v2(187.4,29.93)
PCIE_PTX_SSDRX_P10_C: length 3
  BOTTOM w0.127: CD46.2 185.43,29.74 184.95,29.74 v4(184.65,29.45) 184.39,29.18 184.08,29.18 183.97,29.29 JNGFF2.25
PCIE_PTX_SSDRX_P11: length 96.9
  IN4 w0.091: v2(136.5,73.8) 136.5,73.62 136.6,73.52 136.8,73.52 136.96,73.67 136.96,74.2 137.41,74.66 138.15,74.66 140.6,77.11 146.07,77.11 146.2,76.97 147.49,76.97 147.91,76.55 147.91,76.55 147.93,76.54 154.1,76.54 154.35,76.3 156.93,76.3 157.57,76.93 159.34,76.93 160.35,77.94 164.22,77.94 166.63,75.52 166.63,72.74 168.58,70.8 168.58,69.04 170.31,67.31 170.31,65.49 170.88,64.92 170.88,63.31 170.72,63.16 170.72,61.82 172.58,59.97 172.58,59.47 175.35,56.7 175.35,54.19 178.17,51.36 178.17,46.87 178.64,46.41 179.37,46.41 179.83,46.87 179.83,47.12 180.39,47.68 180.74,47.68 181.31,47.11 181.31,45.89 182.98,44.22 182.98,39.38 185.17,37.19 185.17,33.57 186.41,32.33 187.58,32.33 187.82,32.09 187.82,31.74 187.73,31.65 187.57,31.65 v2(187.38,31.84)
  BOTTOM w0.076: UCPU1.C24 138.12,71.16 138.01,71.05 137.92,71.05 137.72,71.26 137.72,71.36 138,71.64 138,71.73 137.89,71.83 137.89,72.66 137.23,73.32 137.23,73.83 136.98,74.08 136.7,74.08 136.5,73.87 v2(136.5,73.8)
  BOTTOM w0.127: CD51.1 186.99,31.64 187.18,31.64 v2(187.38,31.84)
PCIE_PTX_SSDRX_P11_C: length 3
  BOTTOM w0.127: JNGFF2.37 183.81,32.29 183.96,32.14 184.37,32.14 v4(184.65,31.86) 184.86,31.65 185.44,31.65 CD51.2
PCIE_PTX_TBRX_N1: length 106.6
  TOP w0.127: CT4.2 47.91,68.14 47.91,68.35 48.03,68.47 v2(48.13,68.47)
  IN1 w0.091: v2(48.13,68.47) 47.83,68.76 47.83,68.94 49.47,70.58 56.37,70.58 56.62,70.82 61.7,70.82 62.78,69.74 71.87,69.74 72.92,70.8 82.93,70.8 83.34,71.21 85.6,71.21 85.97,70.83 86.78,70.83 88.02,72.07 93.16,72.07 95.52,74.43 96.21,74.43 98.13,76.35 98.13,76.52 v2(98.35,76.74)
  BOTTOM w0.127: v2(98.35,76.74) 98.17,76.92 98.17,77.43 99.84,79.11 136.98,79.11 141.89,74.2 141.89,73.56 142.41,73.04 142.41,72.78 142.22,72.58 142.22,71.96 UCPU1.B17
PCIE_PTX_TBRX_N1_C: length 3.3
  TOP w0.076: UT1.Y22 46.18,65.14 46.41,65.36 46.41,65.76 46.43,65.78 46.43,65.78 46.76,66.12 46.81,66.12 46.82,66.13 46.82,66.13
  TOP w0.127: 46.82,66.13 46.84,66.13 47.05,66.35 47.37,66.35 47.85,66.83 47.85,67.1 CT4.1
PCIE_PTX_TBRX_N2: length 112.4
  TOP w0.127: v2(45.52,68.46) 45.31,68.26 45.31,68.07 CT8.2
  IN1 w0.091: v2(96.6,76.95) 96.38,76.72 96.38,76.2 93.31,73.14 92.58,73.14 92.13,72.68 86.84,72.68 86.07,71.9 79.65,71.9 79.46,72.09 70.79,72.09 69.07,70.38 63.13,70.38 62.1,71.41 59.64,71.41 59.44,71.61 58.8,72.26 54.59,72.26 53.97,71.64 49.68,71.64 47.69,69.64 45.96,69.64 45.31,69 45.31,68.67 v2(45.52,68.46)
  BOTTOM w0.127: v2(96.6,76.95) 96.42,77.12 96.42,77.55 98.67,79.8 137.71,79.8 143.07,74.43 143.07,71.88 142.82,71.63 142.82,71.55 142.77,71.49 142.77,71.19 143.07,70.88 UCPU1.D16
PCIE_PTX_TBRX_N2_C: length 2.7
  TOP w0.076: UT1.T22 44.56,65.34 44.56,66.11 44.74,66.29 44.76,66.29 44.77,66.29 44.78,66.29
  TOP w0.127: 44.78,66.29 44.79,66.28 45.26,66.76 45.26,67.18 CT8.1
PCIE_PTX_TBRX_P1: length 106.5
  TOP w0.127: v2(47.49,68.49) 47.57,68.49 47.66,68.4 47.66,68.13 CT2.2
  IN1 w0.091: v2(97.71,76.74) 97.94,76.52 97.94,76.43 96.13,74.62 95.44,74.62 93.08,72.26 87.94,72.26 86.7,71.03 86.05,71.03 85.68,71.4 83.26,71.4 82.85,70.99 72.84,70.99 71.79,69.94 62.86,69.94 61.78,71.02 56.54,71.02 56.29,70.77 49.39,70.77 47.64,69.02 47.64,68.64 v2(47.49,68.49)
  BOTTOM w0.127: v2(97.71,76.74) 97.79,76.82 97.79,76.82 97.91,76.95 97.91,77.54 99.74,79.36 137.09,79.36 142.15,74.3 142.15,73.67 142.67,73.15 142.67,72.56 142.51,72.4 UCPU1.A17
PCIE_PTX_TBRX_P1_C: length 3.4
  TOP w0.076: UT1.Y23 46.18,65.44 46.13,65.39 46.03,65.39 45.95,65.47 45.95,65.77 46.08,65.9 46.31,65.9 46.64,66.23 46.64,66.28 46.66,66.3
  TOP w0.127: 46.66,66.3 46.66,66.31 46.95,66.6 47.26,66.6 47.6,66.94 47.6,67.23 CT2.1
PCIE_PTX_TBRX_P2: length 112.5
  TOP w0.127: v2(44.91,68.46) 45.06,68.31 45.06,68.14 44.86,67.94 CT6.2
  IN1 w0.091: v2(95.96,76.95) 96.18,76.72 96.18,76.28 93.23,73.33 92.5,73.33 92.05,72.87 86.76,72.87 85.99,72.09 79.73,72.09 79.54,72.29 70.71,72.29 68.99,70.57 63.21,70.57 62.18,71.61 59.72,71.61 59.58,71.75 58.88,72.45 54.51,72.45 53.89,71.83 49.6,71.83 47.61,69.83 45.88,69.83 45.12,69.08 45.12,68.68 v2(44.91,68.46)
  BOTTOM w0.127: UCPU1.C16 143.07,71.53 143.33,71.78 143.33,74.53 137.81,80.05 98.56,80.05 96.16,77.65 96.16,77.15 v2(95.96,76.95)
PCIE_PTX_TBRX_P2_C: length 2.7
  TOP w0.076: 44.61,66.46 44.6,66.45 44.6,66.38 44.4,66.18 44.4,66.04 44.11,65.75 44.11,65.5 44.2,65.41 44.29,65.41 44.34,65.47 UT1.T23
  TOP w0.127: CT6.1 45.01,67.16 45.01,66.86 44.61,66.46
PCIE_PTX_WLANRX_N5: length 132.1
  IN1 w0.091: v2(40.31,35.44) 40.21,35.44 40.01,35.65 40.01,36.48 40.69,37.17 40.69,37.98 41.63,38.92 42.19,38.92 44.07,40.8 44.07,44.56 45.95,46.43 45.95,48.07 48.66,50.78 48.66,52.53 48.86,52.73 49.29,52.73 50.02,53.46 50.68,53.46 51.79,54.57 56.03,54.57 58.47,57.01 58.47,58.99 63.22,63.74 63.22,65.36 65.01,67.15 77.99,67.15 79.78,68.94 87.39,68.94 88.13,69.68 90.4,69.68 91.05,69.02 92.66,69.02 93.73,70.09 99.8,70.09 100.03,69.86 106.01,69.86 108.82,72.66 111.95,72.66 112.7,73.41 114.91,73.41 115.01,73.31 117.28,73.31 118.73,71.87 122.43,71.87 123.44,70.85 126.31,70.85 126.75,71.28 127.15,71.28 127.51,70.92 129.16,70.92 129.62,71.38 138.05,71.38 138.67,72 140.05,72 140.69,72.64 140.69,72.88 140.89,73.08 141.08,73.08 141.22,72.94 v2(141.22,72.86)
  BOTTOM w0.076: v2(141.22,72.86) 141.28,72.86 141.43,72.71 141.43,72.21 141.37,72.09 141.37,71.94 141.43,71.75 141.43,71.57 141.38,71.43 141.29,71.35 140.98,71.35 140.84,71.2 140.84,70.84 140.88,70.8 140.88,70.74 140.95,70.67 141.07,70.67 141.16,70.76 UCPU1.C19
  BOTTOM w0.127: v2(40.31,35.44) 40.28,35.44 40.04,35.68 40.04,35.83 40.23,36.03 CH11.1
PCIE_PTX_WLANRX_N5_C: length 2
  BOTTOM w0.127: JNGFF1.29 40.25,38.77 40.25,38.09 40.12,37.96 40.12,37.31 CH11.2
PCIE_PTX_WLANRX_P5: length 132.1
  IN1 w0.091: v2(39.65,35.44) 39.81,35.6 39.81,36.56 40.5,37.25 40.5,38.06 41.55,39.11 42.11,39.11 43.88,40.88 43.88,44.64 45.75,46.51 45.75,48.15 48.46,50.86 48.46,52.61 48.78,52.92 49.21,52.92 49.94,53.65 50.6,53.65 51.71,54.76 55.93,54.76 58.28,57.11 58.28,59.07 63.03,63.82 63.03,65.44 64.93,67.34 77.91,67.34 79.7,69.14 87.31,69.14 88.05,69.87 90.48,69.87 91.13,69.21 92.58,69.21 93.65,70.28 99.88,70.28 100.11,70.05 105.93,70.05 108.74,72.86 111.87,72.86 112.62,73.61 114.99,73.61 115.09,73.51 117.36,73.51 118.81,72.06 122.51,72.06 123.52,71.04 126.23,71.04 126.67,71.47 127.23,71.47 127.59,71.11 129.08,71.11 129.54,71.58 137.97,71.58 138.59,72.2 139.97,72.2 140.5,72.72 140.5,72.96 140.81,73.28 141.11,73.28 v2(141.28,73.44)
  BOTTOM w0.076: v2(141.28,73.44) 141.59,73.12 141.59,72.18 141.56,72.08 141.56,71.89 141.59,71.8 141.59,71.55 141.58,71.5 141.53,71.35 141.53,71.24 141.52,71.18 141.38,70.69 141.38,70.58 UCPU1.D19
  BOTTOM w0.127: v2(39.65,35.44) 39.75,35.54 39.75,35.81 39.53,36.03 CH12.1
PCIE_PTX_WLANRX_P5_C: length 2
  BOTTOM w0.127: CH12.2 39.86,37.33 39.86,37.92 39.75,38.03 39.75,38.77 JNGFF1.27
PCIE_RBIAS: length 18.8
  TOP w0.203: UT1.N16 v2(42.82,62.79)
  TOP w0.305: RT1.2 49.25,68.28 48.81,67.85 48.81,67.26 48.01,66.46 v2(48.01,66)
  IN3 w0.102: 44.61,64.58 46.34,64.58 46.76,64.16 46.76,62.21 46.24,61.69 44.55,61.69 43.56,62.68 42.93,62.68 v2(42.82,62.79)
  IN3 w0.152: 43.94,63.91 v2(42.82,62.79)
  IN3 w0.254: 43.94,63.91 45.63,65.6 47.47,65.6 47.87,66 v2(48.01,66)
PCIE_RCOMPN: length 2
  TOP w0.305: RC45.1 149.52,69.23 v2(148.95,69.23) 148.23,69.23 v3(148.21,69.25)
  BOTTOM w0.254: v2(148.95,69.23) 149.46,68.96 UCPU1.F5
PCIE_RCOMPP: length 3.5
  TOP w0.102: v2(150.22,69.99) 150.67,69.99 151.51,70.83 v3(151.51,70.96)
  TOP w0.305: RC45.2 149.99,70.21 v2(150.22,69.99)
  BOTTOM w0.254: UCPU1.E5 149.43,69.59 149.82,69.99 v2(150.22,69.99)
PCIE_WAKE#: length 226.9
  TOP w0.127: UE5.B8 187.21,62.77 186.91,62.77 v2(186.46,62.32) ; v2(44.86,37.65) 45.02,37.65 45.62,37.05 45.67,37 v3(46.15,37)
  IN1 w0.089: v2(186.46,62.32) 186.21,62.32 185.76,61.86 182.55,61.86 181.64,60.94 181.64,58.99 181.28,58.63 179.88,58.63 177.59,56.34 177.59,54.18 177.76,54.01 177.76,53.42 177.19,52.85 176.08,52.85 175.13,51.91 175.13,50.96 175.54,50.55 175.54,49.32 173.73,47.51 173.73,46.84 172.11,45.22 172.11,43.57 171.7,43.17 171.7,39.54 169.9,37.74 169.9,35.17 172.31,32.76 172.31,21.17 171.56,20.42 162.75,20.42 161.39,19.06 158.71,19.06 156.91,17.27 152.35,17.27 150.98,15.9 134.14,15.9 131.96,18.08 126.77,18.08 125.92,17.23 116.65,17.23 116.11,17.78 112.12,17.78 111.66,18.23 103.14,18.23 101.45,19.91 96.49,19.91 94.18,22.22 92.58,22.22 89.19,25.6 82.86,25.6 81.98,24.71 79.29,24.71 78.61,25.4 76.13,25.4 71.34,20.61 69.26,20.61 66.9,18.25 66.35,18.25 64.52,20.08 63.29,20.08 62.42,20.95 54.98,20.95 54.77,20.74 52.27,20.74 50.9,19.37 49.64,19.37 48.22,17.95 47.05,17.95 47.03,17.94 43.8,17.94 43.54,18.2 43.54,19.72 42.51,20.74 42.51,21.79 41.92,22.39 41.03,22.39 37.78,25.63 37.78,31.36 39.26,32.84 40.2,32.84 42.34,34.98 42.34,35.42 44.58,37.65 v2(44.86,37.65)
  BOTTOM w0.127: RE120.2 45.47,37.65 v2(44.86,37.65) 44.75,37.76 JNGFF1.47 ; v2(186.46,62.32) 186.6,62.17 RE86.1
PD_EE_CLK: length 24.1
  TOP w0.127: U722.A3 26.15,63.61 v2(26.49,63.61) ; v2(27.47,46.67) 27.36,46.56 26.85,46.56 26.28,47.14 23.71,47.14 22.96,46.39 UT6.6
  IN1 w0.081: v2(27.47,46.67) 27.69,46.9 27.69,48.61 27.63,48.67 27.63,53.04 25.48,55.19 25.48,56.88 25.93,57.34 25.93,63.05 v2(26.49,63.61)
PD_EE_CS#: length 31.9
  TOP w0.076: U722.B3 v2(24.99,63.47)
  TOP w0.127: v2(24.85,45.45) 25.69,44.61 v1(25.69,43.46) 25.69,42.6 24.58,41.49 20.89,41.49 20.42,41.02 UT6.1 20.42,39.53 R1477.2
  IN1 w0.081: v2(24.99,63.47) 25.52,62.95 25.52,57.51 25.06,57.06 25.06,55.02 26.89,53.19 26.89,49.94 26.42,49.48 26.42,48.03 24.85,46.46 v2(24.85,45.45)
PD_EE_DI: length 26.3
  TOP w0.076: v2(26.49,62.77) 26.44,62.72 25.76,62.72 U722.B4
  TOP w0.127: v1(25.57,46.34) UT6.5 24.23,45.45 v2(24.24,45.45)
  IN1 w0.081: v2(24.24,45.45) 24.24,44.9 24.46,44.67 26.65,44.67 27.98,46 27.98,48.62 27.84,48.76 27.84,53.13 25.69,55.28 25.69,56.8 26.14,57.25 26.14,62.42 v2(26.49,62.77)
PD_EE_DO: length 32.9
  TOP w0.127: U722.A4 26.25,63.21 26.7,63.21 27.12,63.62 v2(27.12,63.72) 27.71,64.32 R1475.2 ; UT6.2 21.69,40.83 22.06,41.19 24.66,41.19 26.07,42.6 26.07,44.7 v3(26.25,44.87) v2(27.05,45.68)
  IN1 w0.081: v2(27.05,45.68) 26.37,46.35 26.37,47.69 26.63,47.94 26.63,49.39 27.1,49.86 27.1,53.28 25.27,55.11 25.27,56.97 25.73,57.42 25.73,63.4 26.33,64.01 26.83,64.01 v2(27.12,63.72)
PD_EE_WP#: length 2.6
  TOP w0.127: UT6.3 22.96,39.53 R1474.2 v1(22.46,39.02)
PD_HOLD#: length 3.7
  TOP w0.127: UT6.7 21.69,46.88 22.01,47.2 22.57,47.2 R1476.2 23.4,48.03 v1(24.39,48.03)
PD_OVP: length 4.1
  TOP w0.127: v1(93.08,69.61) 92.56,70.13 91.82,70.13 PR288.1 91.39,68.86 PR253.2 91.09,68.55 PQ218.6
PD_SENSEN: length 33.2
  TOP w0.076: v2(27.13,59.32) 26.73,59.32 26.07,59.97 U722.A10
  TOP w0.127: v3(39.02,78.14) PR236.2
  TOP w0.254: PR236.2 40.32,78.35 v2(40.32,78.99)
  IN1 w0.254: v2(31.38,67.12) 31.38,67.03 30.99,66.64 30.6,66.64 30.15,67.09 30.15,69.4 33.79,73.05 35.07,73.05 40.4,78.38 40.4,78.9 v2(40.32,78.99)
  IN3 w0.254: v2(31.38,67.12) 31.26,66.99 31.26,66.58 30.62,65.94 29.57,65.94 28.95,65.32 28.95,62.55 29.38,62.12 29.38,60.53 28.86,60.01 27.66,60.01 27.13,59.47 v2(27.13,59.32)
PD_SENSEP: length 30.2
  TOP w0.076: v2(26.73,59.84) 26.34,60.23 25.76,60.23 25.51,59.97 U722.B10
  TOP w0.254: PR238.2 40.9,78.23 40.9,78.98 v2(40.92,78.99)
  IN1 w0.254: v2(30.8,67.13) 30.53,67.39 30.53,69.24 33.95,72.67 35.23,72.67 40.79,78.22 40.79,78.86 v2(40.92,78.99)
  IN3 w0.254: v2(26.73,59.84) 26.96,59.84 27.51,60.39 28.7,60.39 29,60.69 29,61.96 28.57,62.4 28.57,65.47 29.41,66.32 30.46,66.32 30.87,66.73 30.87,67.05 v2(30.8,67.13)
PECI_EC: length 79.3
  IN2 w0.089: v2(157.76,67.97) 157.76,66.92 159.75,64.93 161.08,64.93 161.5,64.51 165.96,64.51 166.11,64.37 168.02,64.37 168.25,64.6 171.43,64.6 171.53,64.49 174.62,64.49 174.7,64.57 175.11,64.57 175.66,64.02 175.66,63.43 v2(175.29,63.06)
  IN4 w0.081: v2(157.76,67.97) 157.21,68.51 155.12,68.51 154.69,68.94 151.69,68.94 151.61,68.87 150.44,68.87 149.66,69.66 149.66,69.88 148.92,70.62 145.57,70.62 145.06,70.11 145.06,67.7 144.83,67.48 138.02,67.48 137.38,68.12 128.51,68.12 128.41,68.22 126.93,68.22 126.59,68.56 126.59,70.19 125.73,71.05 125.33,71.05 122.44,73.95 121.41,73.95 120.68,74.68 120.68,75.12 v2(120.7,75.14)
  BOTTOM w0.076: v2(120.7,75.14) 120.63,75.07 120.63,74.46 121.45,73.64 121.45,72.58 121.34,72.47 UCPU1.A54
  BOTTOM w0.127: RE61.2 174.12,58.07 174.12,59.69 174.42,59.99 175.09,59.99 175.33,60.22 175.33,60.56 174.66,61.24 174.66,62.43 v2(175.29,63.06)
PECI_EC_R: length 4.4
  TOP w0.127: UE5.A48 176.91,59.52 176.48,59.09 176.48,58.86 v2(176.25,58.63)
  BOTTOM w0.127: v2(176.25,58.63) 176.25,58.63 v3(175.85,58.24) 175.85,57.25 RE61.1 176.63,56.47 CE68.1
PME#: length 1.1
  TOP w0.127: T115.1 145.5,52.49 v2(145.39,52.49)
  BOTTOM w0.076: UCPU1.AU11 145.7,52.8 v2(145.39,52.49)
POWER_SW_IN#: length 15.2
  TOP w0.127: UE5.B67 186.11,59.29 v2(185.92,59.48) ; v2(188.39,54.01) 188.95,53.45 RE31.2 ; RE33.1 188.93,53.3 RE31.2 ; RE31.2 189.81,53.32 CE49.1
  IN2 w0.089: v2(185.92,59.48) 186.28,59.85 188.01,59.85 188.81,59.05 188.81,58.49 187.97,57.65 187.97,54.43 v2(188.39,54.01)
  BOTTOM w0.127: RE35.1 188.39,51.65 v2(188.39,54.01)
PS_ID: length 191.9
  TOP w0.127: PR102.2 25.11,68.76 PR103.2 27.14,66.81 28.25,66.81 28.96,67.52 29.76,67.52 29.9,67.38 v2(29.9,65.46) ; UE5.B24 183.61,67.63 183.74,67.5 183.74,66.56 183.29,66.1 182.83,66.1 v2(182.4,66.53)
  IN1 w0.081: v2(184.02,72.53) 184.18,72.37 184.18,70.11 183.54,69.46 183.54,66.48 183.21,66.15 182.86,66.15 182.47,66.53 v2(182.4,66.53)
  IN3 w0.089: v2(29.9,65.46) 31.06,65.46 31.69,66.09 36.63,66.09 37.87,67.33 43.27,67.33 44.25,66.35 44.65,66.35 45.36,67.06 48.69,67.06 51.3,69.67 51.3,70.89 52.19,71.78 52.62,71.78 52.97,72.13 52.97,73.81 57.87,78.7 61.96,78.7 62.43,78.23 62.76,78.23 63.27,78.74 68.68,78.74 70.83,76.59 79.14,76.59 80.19,75.54 83.72,75.54 84.12,75.94 90.1,75.94 93,78.84 129.17,78.84 129.27,78.94 150.94,78.94 151.76,78.11 154.53,78.11 155.19,77.45 156.03,77.45 v2(156.07,77.41)
  BOTTOM w0.127: v2(184.02,72.53) 184.02,73.66 182.86,74.82 181.44,74.82 181.02,75.24 178.65,75.24 178.4,75.5 177.68,75.5 v3(176.58,76.6) 175,76.6 173.46,78.14 172.38,78.14 170.8,76.56 167.15,76.56 166.78,76.94 166.78,77.83 165.55,79.06 157.72,79.06 v2(156.07,77.41)
PTP_DIS#: length 162.8
  BOTTOM w0.127: JTP1.6 184.16,19.36 184.16,19.84 184,20 183.43,20 182.02,21.41 181.24,21.41 180.65,20.81 180.65,19.54 179.3,18.2 167.59,18.2 167.37,17.98 167.37,16.35 166.65,15.63 166.65,13.91 166.3,13.57 135.12,13.57 130.87,17.82 127.43,17.82 125.1,15.49 114.46,15.49 112.05,17.9 107.04,17.9 105.69,16.54 95.46,16.54 94.31,15.39 63.77,15.39 62.26,13.88 59.37,13.88 55.85,17.41 51.21,17.41 48.26,14.46 40.69,14.46 v2(40.13,15.02) 38.06,15.02 37.5,15.58 UE4.21
PTP_INT#_EC: length 100.5
  TOP w0.127: Q40.1 183.57,18.98 182.31,20.24 182.31,20.52 v2(182.04,20.79) 182.04,21.08 v3(181.36,21.76) ; v2(188.47,57.06) 189.92,58.51 191.24,58.51 RPE5.2 ; v2(179.17,65.96) 179.17,65.97 179.15,66 179.15,66.02 179.1,66.07 178.69,66.07 178.49,66.27 178.01,66.27 UE5.B37
  IN1 w0.081: v2(179.17,65.96) 178.58,65.96 177.44,64.82 177.44,63.5 176.82,62.89 176.21,62.89 175.43,63.68 174.56,63.68 173.78,62.89 173.78,61.21 173.69,61.12 173.69,59.54 172.33,58.18 172.33,53.62 v2(172.24,53.53) ; v2(182.04,20.79) 182.68,21.42 182.68,41.56 185.14,44.02 185.14,46.44 185.91,47.21 188.31,47.21 189.34,48.23 189.34,49.63 191.08,51.37 191.08,52.93 190.4,53.6 190.4,55.02 188.47,56.95 v2(188.47,57.06)
  IN3 w0.089: v2(159.23,48.91) 159.44,49.11 160.85,49.11 161.16,49.43 164.61,49.43 169.02,53.84 171.25,53.84 171.56,53.53 v2(172.24,53.53)
  IN4 w0.081: v2(179.17,65.96) 179.17,65.27 179.52,64.91 180.33,64.91 183,62.24 183,59.14 183.58,58.57 186.56,58.57 188.08,57.06 v2(188.47,57.06)
  BOTTOM w0.127: DZ3.1 159.11,48.78 v2(159.23,48.91)
PTP_INT#_R: length 5.8
  TOP w0.127: Q40.3 183.02,20.52 v2(183.55,21.05) 183.55,21.51 183.08,21.98 R1299.2 183.08,23.15 v3(183.47,23.53)
  BOTTOM w0.127: JTP1.5 184.66,19.36 184.66,19.87 183.55,20.98 v2(183.55,21.05)
PWM1_GT: length 15.3
  TOP w0.127: v3(81.97,50.64) 81.27,50.64 80.8,50.16 v2(80.77,50.16)
  TOP w0.203: v2(72.49,51.39) 72.49,51.68 72.01,52.16 71.63,52.16 PU1000.12
  IN3 w0.203: v2(80.77,50.16) 80.77,50.18 80.82,50.18 80.82,50.19 80.8,50.21 80.8,50.58 80.11,51.27 74.32,51.27 73.71,50.66 72.9,50.66 72.49,51.06 v2(72.49,51.39)
  BOTTOM w0.203: v2(80.77,50.16) 80.77,50.18 80.82,50.18 80.82,50.19 80.8,50.21 80.8,50.57 80.6,50.76 PR1117.1 80.29,50.63 80.29,49.61 80.43,49.48 PU1102.8
PWM2_GT: length 15.2
  TOP w0.127: v2(73.03,51.95) 72.64,51.95 72.03,52.56 71.51,52.56 PU1000.13
  TOP w0.508: PR1108.1 79.22,58.76 v2(80.24,57.74)
  IN3 w0.203: v2(73.03,51.95) 73.3,52.23 75.79,52.23 77.78,54.21 77.78,55.03 78.77,56.02 78.77,57.01 79.5,57.74 v2(80.24,57.74)
  BOTTOM w0.203: PU1101.8 80.39,57.1 80.24,57.25 v2(80.24,57.74)
PWM_IA: length 23.8
  TOP w0.203: PU1000.22 70.36,56.52 71.04,57.21 v2(71.22,57.21)
  IN4 w0.203: v2(79.43,65.59) 79.48,65.64 80.08,65.64 80.77,64.95 80.77,59.4 78.25,56.88 73.36,56.88 72.31,55.84 71.73,55.84 71.22,56.34 v2(71.22,57.21)
  BOTTOM w0.203: PR1104.1 79.22,65.79 v2(79.43,65.59) 79.45,65.62 80.09,65.62 80.14,65.57 PU1100.8
PWM_VSA: length 7.3
  TOP w0.203: PU1305.3 63.97,60.91 64.47,60.41 65.13,60.41 v3(65.66,59.88) 65.91,59.62 65.91,57.64 67.16,56.4 PU1000.30
PWR_SRC_LIMIT: length 113.9
  TOP w0.127: PU201.1 90.33,72.01 v2(90.68,71.66) 90.86,71.84 PC205.1 91.4,71.84 91.89,71.35 92.58,71.35 92.77,71.55 92.77,71.89 93.45,72.56 93.45,73.78 94.06,74.4 94.06,75.08 93.33,75.81 92.54,75.81 PR227.2 92.15,75.52 91.36,76.32 91.36,77.54 91.22,77.68 88.56,77.68 PD201.2 88.32,76.66 PR226.2 ; U722.G10 23.01,60.04 v2(22.6,60.45) ; PR216.1 57.81,60.49 57.28,61.02 v2(57.28,62.24)
  IN1 w0.081: v2(57.28,62.24) 57.28,61.58 55.6,59.9 52.35,59.9 v2(52.15,60.11)
  IN3 w0.089: v2(52.15,60.11) 52.03,59.99 52.03,53.64 51.33,52.94 49.94,52.94 49.54,52.55 49.54,52.13 48.88,51.47 47.65,51.47 47.45,51.67 46.79,51.67 46.48,51.37 38.75,51.37 37.9,52.22 37.9,53.7 37.08,54.53 34.57,54.53 33.24,55.86 31.17,55.86 30.27,56.77 29.26,56.77 28.92,57.11 25.26,57.11 24.11,58.26 24.11,59.15 23.65,59.61 23.06,59.61 22.6,60.08 v2(22.6,60.45)
  BOTTOM w0.127: v2(90.68,71.66) 91.39,70.95 91.39,69.75 90.2,68.56 87,68.56 84.62,70.94 83.57,70.94 82.81,70.19 79.5,70.19 79.15,70.54 75.79,70.54 75.44,70.19 74.02,70.19 72.5,68.68 67.88,68.68 67.76,68.8 64.06,68.8 63.86,68.6 60.66,68.6 59.88,67.83 59.88,64.17 v3(59.41,63.7) 57.95,62.24 v2(57.28,62.24)
PWR_SRC_ON: length 186.8
  TOP w0.127: PR218.2 61.18,49.98 59.59,51.56 v2(59.59,51.57) ; v2(179.22,63.78) 179,63.56 178.47,63.56 178.26,63.77 UE5.B42
  IN3 w0.089: v2(50.14,69.73) 50.58,70.17 50.58,72.34 58.51,80.26 69.98,80.26 71.39,78.84 72.17,78.84 72.35,79.02 73.33,79.02 73.66,78.69 78.57,78.69 80.64,76.62 83.28,76.62 84.36,77.69 89.11,77.69 89.74,78.33 89.74,78.83 90.89,79.98 151.47,79.98 152.27,79.18 155.3,79.18 155.7,79.58 172.19,79.58 177.95,73.83 178.65,73.83 v2(179.63,74.81)
  IN4 w0.081: v2(50.14,69.73) 50.14,69.65 51.71,68.08 51.71,66.53 52.14,66.1 52.14,65.7 52.64,65.2 v2(52.64,65.2)
  IN4 w0.089: v2(179.22,63.78) 179.05,63.61 178.36,63.61 178.1,63.86 178.1,68.86 177.69,69.27 177.69,71.04 177.5,71.23 177.5,72.14 178.33,72.98 178.33,73.52 v2(179.63,74.81)
  BOTTOM w0.127: v2(59.59,51.57) 58.7,50.68 v3(58.06,50.68) 55.08,50.68 54.98,50.58 54.57,50.58 54.07,51.08 52.74,51.08 51.69,52.13 51.69,60.73 52.35,61.39 52.35,64.39 52.34,64.4 52.34,64.75 52.35,64.76 52.35,64.91 v2(52.64,65.2)
PWR_SRC_ON_PC: length 53.2
  TOP w0.076: 24.77,59.17 24.77,59.7 24.51,59.95 U722.D10
  TOP w0.127: v2(25.12,58.43) 25.12,58.81 24.77,59.17
  TOP w0.508: v2(59.61,50.91) 59.86,50.67 PR229.2
  IN2 w0.508: v2(25.12,58.43) 28.55,58.43 30.74,56.24 30.74,50.35 v2(29.46,49.06)
  IN3 w0.406: v2(29.46,49.06) 31.13,49.06 36.81,43.39 38.33,43.39 38.92,42.8 41.15,42.8 41.58,42.38 43.89,42.38 51.05,49.54 52.02,49.54 52.88,50.4 54.99,50.4 55.51,50.91 v2(59.61,50.91)
PWR_TB_DOCK#: length 248.7
  TOP w0.127: v2(30,60.49) 30.46,60.94 30.46,61.63 R1440.2
  IN1 w0.089: v2(40.82,15.02) 40.82,14.72 42.27,13.26 49.53,13.26 51.14,14.88 53.89,14.88 54.59,14.18 58.57,14.18 59.31,14.92 66.22,14.92 66.43,15.12 70.44,15.12 71.03,15.71 94.04,15.71 94.84,16.51 100.72,16.51 102.07,15.16 108.38,15.16 109.09,15.87 110.69,15.87 111.4,15.16 115.36,15.16 116.36,14.16 126.31,14.16 127.79,15.63 130.94,15.63 133.05,13.52 174.88,13.52 180.7,19.34 180.7,25.49 178.48,27.7 178.48,30.86 179.17,31.56 179.17,34.63 180.32,35.77 180.32,40.5 179.72,41.09 179.33,41.09 179.02,40.78 177.77,40.78 176.56,41.99 176.56,43.66 177.05,44.14 178.24,44.14 178.68,43.7 181.12,43.7 187.28,49.87 v2(188.52,49.87)
  IN2 w0.089: v2(30,60.49) 30,59.04 31.17,57.87 31.17,48.53 32.65,47.04 32.65,45.75 34.87,43.53 34.87,41.46 34.3,40.89 34.3,39.32 34.77,38.85 34.77,32.53 35.27,32.03 35.27,31.84 33.79,30.36 33.79,25.85 34.37,25.27 34.37,23.06 33.21,21.9 33.21,21.15 37.82,16.54 38.91,16.54 40.03,15.43 40.41,15.43 v2(40.82,15.02)
  BOTTOM w0.127: v1(188.58,49.36) 188.52,49.42 v2(188.52,49.87) 188.57,49.92 RE35.2
PWRBTN_LED#: length 68.8
  TOP w0.127: v2(181.24,59.85) 181.24,59.1 181.11,58.97 UE5.B57
  IN4 w0.081: v2(181.24,59.85) 181.51,59.58 181.51,58.87 182.23,58.14 186.39,58.14 187.53,57 187.53,56.22 185.89,54.59 185.89,53.35 188.79,50.45 190.54,50.45 190.85,50.15 190.85,48.75 193.5,46.1 193.5,34.25 193.82,33.93 194.96,33.93 195.8,33.09 195.8,26.08 198.17,23.71 200.4,23.71 201.47,22.64 203.2,22.64 205.16,20.68 205.16,19.39 203.09,17.32 202.5,17.32 v2(202.36,17.18)
  BOTTOM w0.127: JIO1.41 198.21,15.54 198.21,16.08 199.03,16.9 202.08,16.9 v2(202.36,17.18) ; v2(181.24,59.85) v1(180.65,59.85)
REM_DIODE1_N: length 74.5
  TOP w0.127: v2(138.35,63.13) 138.96,62.52 CE47.1 138.06,62.29 QE3.3 ; v2(186.55,65.7) 186.54,65.69 186.96,65.27 UE5.B13
  IN3 w0.127: v2(190.75,67.34) 191.21,67.8 191.21,69.41 188.59,72.03 184.95,72.03 184.73,72.25 184.73,72.78 184.15,73.36 181.05,73.36 180.2,72.52 177.54,72.52 177.34,72.32 174.46,72.32 173.05,70.9 172.19,70.9 171.81,70.52 171.81,69 171.48,68.67 169.44,68.67 168.93,69.17 166.77,69.17 165.8,68.2 163.57,68.2 162.48,67.12 160.45,67.12 157.86,64.53 157.86,62.65 157.33,62.11 153.54,62.11 151.7,60.27 145.41,60.27 144.84,60.84 142.95,60.84 142.45,61.34 141.38,61.34 140.69,62.04 139.06,62.04 138.48,62.62 138.48,63 v2(138.35,63.13)
  BOTTOM w0.127: v2(190.75,67.34) 190.7,67.34 190.42,67.06 190.26,67.06 CE58.1 189.64,67.01 189.36,67.01 188.92,66.58 188.07,66.58 187.18,65.7 v2(186.55,65.7)
REM_DIODE1_P: length 76.2
  TOP w0.127: QE3.1 136.45,61.81 137.05,61.21 137.84,61.21 QE3.2 138.75,61.16 CE47.2 138.62,61.72 138.47,61.72 v2(138.39,61.8) ; UE5.A13 188.37,65.52 v2(188.75,65.91)
  IN3 w0.127: v2(138.39,61.8) 138.6,62.01 138.78,62.01 138.97,61.82 140.6,61.82 141.33,61.09 142.35,61.09 142.85,60.59 144.73,60.59 145.26,60.05 151.79,60.05 153.63,61.9 157.42,61.9 158.08,62.56 158.08,64.39 160.55,66.86 162.59,66.86 163.48,67.75 163.71,67.99 165.89,67.99 166.86,68.96 168.84,68.96 169.35,68.45 171.57,68.45 172.02,68.91 172.02,70.38 172.29,70.65 173.15,70.65 174.57,72.06 177.39,72.06 177.63,72.3 180.35,72.3 181.15,73.11 184.05,73.11 184.48,72.68 184.48,72.2 184.86,71.82 188.5,71.82 191,69.32 191,68.22 190.32,67.55 190.32,67.12 190.7,66.73 v2(190.83,66.73)
  BOTTOM w0.127: v2(188.75,65.91) 188.5,65.65 187.88,65.65 187.8,65.72 187.8,65.96 188.17,66.33 189.03,66.33 189.46,66.76 189.64,66.76 CE58.2 190.31,66.77 190.8,66.77 v2(190.83,66.73)
REM_DIODE2_N: length 313.5
  TOP w0.127: v2(186.25,66.2) 186.36,66.2 186.43,66.14 186.65,66.14 187.02,65.77 UE5.B14 ; v2(193.32,66.49) 193.53,66.28 193.85,66.28 CE67.1 194.53,66.21 194.98,66.21 v2(195.12,66.35)
  IN1 w0.127: v2(186.25,66.2) 187.33,66.2 187.69,66.56 187.69,66.96 188.57,67.84 189.05,67.84 190.59,66.3 192.92,66.3 192.93,66.3 193.13,66.3 v2(193.32,66.49) ; v2(46.76,34.73) 46.69,34.73 46.51,34.55 46.51,34.43 46.69,34.25 47.13,34.25 49.87,36.99 50.88,36.99 51.28,36.58 53.13,36.58 53.51,36.97 61.36,36.97 63.05,38.66 68.31,38.66 70.23,36.74 72.23,36.74 72.71,37.22 77.12,37.22 79.51,34.83 81.94,34.83 82.31,35.2 89.08,35.2 90.24,34.04 91.33,34.04 92.56,32.82 92.82,32.82 93.42,32.22 v2(93.73,32.22)
  IN2 w0.127: v2(106.06,44.19) 106.53,43.72 106.53,43.42 106.23,43.12 102.6,43.12 100.91,41.44 100.91,35.87 99.82,34.78 98.2,34.78 98.07,34.65 95.17,34.65 94.29,33.77 94.29,32.77 v2(94.23,32.72)
  IN3 w0.127: v2(94.23,32.72) 94.38,32.57 94.38,28.65 93.86,28.13 93.86,26.46 93.64,26.24 93.64,24.96 94.95,23.65 94.95,22.62 95.65,21.91 96.89,21.91 99.16,19.64 102.12,19.64 103.29,18.47 106.16,18.47 107,19.31 156.39,19.31 161.82,24.75 161.82,25.29 162.08,25.54 163.46,26.92 163.46,29.94 164.52,31 164.52,34.18 164.05,34.65 164.05,36.57 164.46,36.98 166.52,36.98 167.04,37.5 168.76,37.5 169.57,36.69 170.92,36.69 172.37,38.13 173.4,38.13 174.01,37.52 180.16,37.52 182.16,39.52 182.16,43.07 180.79,44.44 179.68,44.44 178.38,45.74 178.38,46.75 177.89,47.24 177.89,48.63 178.52,49.26 178.52,50.46 179.1,51.05 179.1,51.47 179.57,51.94 181.02,51.94 181.55,51.41 187.88,51.41 190.31,53.84 190.31,57.32 190.48,57.5 191.62,57.5 192.95,58.83 193.16,58.83 195.96,61.63 195.96,65.69 195.55,66.1 195.38,66.1 v2(195.12,66.35) ; v2(46.76,34.73) 46.53,34.96 46.53,35.31 45.67,36.18 40.41,36.18 39.85,36.74 39.85,37.96 38.59,39.23 34.98,39.23 33.69,40.51 33.69,42.14 31.85,43.98 31.85,45.4 30.53,46.72 28.64,46.72 26.81,48.55 26.81,54.46 27.2,54.85 27.2,55.15 v2(26.73,55.62)
  BOTTOM w0.127: QE4.3 107.43,45.96 CE48.2 105.89,45.45 105.89,44.36 v2(106.06,44.19) 104.92,43.05 101.61,43.05 100.43,41.87 100.43,39.29 96.03,34.89 96.03,32.72 95.35,32.04 93.91,32.04 v2(93.73,32.22) ; v2(26.73,55.62) 26.56,55.46 26.24,55.46 25.99,55.71 23.66,55.71 23.34,56.03 CE57.2 23.67,56.79 23.9,56.79 QE11.2 25.67,56.27 QE11.1
REM_DIODE2_P: length 312.8
  TOP w0.127: v2(193.32,65.83) 193.48,65.98 193.5,65.98 193.54,66.02 193.8,66.02 CE67.2 194.45,65.96 194.91,65.96 v2(195.1,65.77) ; UE5.A14 188.06,66.02 188.31,66.02 188.6,66.3 189.14,66.3 v2(189.34,66.1)
  IN1 w0.127: v2(193.32,65.83) 193.11,66.04 192.82,66.04 192.82,66.05 190.48,66.05 188.95,67.59 188.67,67.59 187.94,66.86 187.94,66.63 188.24,66.33 189.11,66.33 v2(189.34,66.1) ; v2(93.8,31.56) 93.73,31.56 92.71,32.57 92.45,32.57 91.23,33.79 90.13,33.79 88.98,34.95 82.41,34.95 82.04,34.58 79.4,34.58 77.01,36.97 72.81,36.97 72.33,36.49 70.12,36.49 68.21,38.4 63.16,38.4 61.47,36.71 53.62,36.71 53.24,36.33 51.18,36.33 50.77,36.74 49.98,36.74 47.23,33.99 46.58,33.99 46.25,34.32 46.25,34.58 v2(46.05,34.78)
  IN2 w0.127: v2(93.9,33.31) 94.03,33.44 94.03,33.87 95.07,34.91 97.96,34.91 98.09,35.04 99.72,35.04 100.66,35.98 100.66,41.54 102.5,43.38 105.88,43.38 v2(106.07,43.57)
  IN3 w0.127: v2(46.05,34.78) 46.28,35.01 46.28,35.21 45.56,35.92 40.31,35.92 39.6,36.63 39.6,37.85 38.48,38.97 34.87,38.97 33.44,40.41 33.44,42.03 31.6,43.87 31.6,45.35 30.48,46.47 28.53,46.47 26.59,48.41 26.59,54.85 v2(26.75,55) ; v2(195.1,65.77) 195.22,65.89 195.23,65.88 195.46,65.88 195.75,65.6 195.75,61.72 193.07,59.05 192.86,59.05 191.53,57.71 190.39,57.71 190.09,57.41 190.09,53.93 187.79,51.63 181.64,51.63 181.11,52.16 179.48,52.16 178.89,51.56 178.89,51.14 178.3,50.55 178.3,49.35 177.67,48.72 177.67,47.15 178.16,46.66 178.16,45.65 179.59,44.22 180.7,44.22 181.94,42.98 181.94,39.61 180.07,37.74 174.1,37.74 173.49,38.35 172.28,38.35 170.83,36.9 169.66,36.9 168.85,37.72 166.95,37.72 166.43,37.2 164.37,37.2 163.84,36.66 163.84,34.56 164.31,34.09 164.31,31.09 163.24,30.03 163.24,27.04 161.61,25.41 161.61,24.84 156.3,19.53 106.91,19.53 106.07,18.68 103.38,18.68 102.21,19.86 99.24,19.86 96.98,22.13 95.74,22.13 95.16,22.71 95.16,23.74 93.85,25.05 93.85,26.15 94.08,26.37 94.08,28.04 94.6,28.56 94.6,32.02 94.68,32.09 94.68,33 94.38,33.3 93.92,33.3 v2(93.9,33.31)
  BOTTOM w0.127: v2(26.75,55) 26.54,55.2 26.14,55.2 25.88,55.46 23.53,55.46 22.84,56.16 22.84,56.87 CE57.1 23.67,57.04 23.9,57.04 QE11.3 ; QE4.1 108.93,44.9 107.68,44.9 QE4.2 107.53,45.04 CE48.1 106.4,44.64 106.48,44.55 106.48,43.71 106.27,43.49 106.15,43.49 v2(106.07,43.57) 105.3,42.8 101.72,42.8 100.69,41.76 100.69,39.19 96.28,34.79 96.28,32.61 95.45,31.78 94.03,31.78 v2(93.8,31.56)
REM_DIODE3_N: length 64.9
  TOP w0.127: v2(153.06,41.39) 153.06,40.91 152.68,40.52 149.17,40.52 148.9,40.25 148.9,40.04 148.69,39.84 CE66.2 148.82,39.56 148.82,39.08 148.3,38.56 QE10.3 ; UE5.A15 188.06,66.52 188.23,66.52 188.79,67.08 v2(188.79,67.11)
  IN3 w0.127: v2(153.06,41.39) 153.21,41.39 153.31,41.49 153.31,41.74 153.64,42.07 154.86,42.07 155.11,42.33 156.36,42.33 158.85,44.81 158.85,45.98 160.59,47.72 161.27,47.72 162.15,48.6 165.73,48.6 167.11,49.97 167.11,50.61 169.29,52.79 170.97,52.79 171.31,52.46 172.87,52.46 173.58,53.17 175.75,53.17 177.82,55.24 180.66,55.24 180.96,55.54 181.84,55.54 182.09,55.79 182.09,56.35 181.76,56.67 181.76,58.4 181.67,58.5 181.67,64 183.49,65.82 183.49,67.53 184.1,68.13 186.53,68.13 187.15,68.75 187.7,68.75 187.97,68.48 187.97,68.31 v2(188.18,68.1)
  BOTTOM w0.127: v2(188.18,68.1) 187.97,67.89 187.97,67.62 187.84,67.49 187.84,67.3 188.12,67.01 CE39.1 188.7,67.01 v2(188.79,67.11)
REM_DIODE3_P: length 66.2
  TOP w0.127: UE5.B16 186.69,66.77 186.58,66.88 186.58,66.9 186.59,66.91 v2(186.59,66.96) ; QE10.1 149.6,37.31 QE10.2 149.07,39.08 149.07,39.46 CE66.1 149.32,39.84 149.15,40 149.15,40.14 149.28,40.27 152.78,40.27 153.31,40.8 153.31,40.9 v2(153.72,41.31)
  IN3 w0.127: v2(187.58,68.09) 187.75,68.27 187.75,68.39 187.61,68.53 187.24,68.53 186.62,67.92 184.19,67.92 183.71,67.44 183.71,65.73 181.89,63.91 181.89,58.59 181.98,58.49 181.98,56.76 182.3,56.44 182.3,55.7 181.93,55.33 181.05,55.33 180.75,55.02 177.91,55.02 175.84,52.96 173.67,52.96 172.96,52.24 171.22,52.24 170.88,52.57 169.38,52.57 167.32,50.52 167.32,49.88 165.82,48.38 162.24,48.38 161.36,47.5 160.68,47.5 159.06,45.89 159.06,44.72 156.45,42.11 155.2,42.11 154.95,41.86 153.73,41.86 153.53,41.66 153.53,41.5 v2(153.72,41.31)
  BOTTOM w0.127: v2(186.59,66.96) 186.65,67.01 CE39.2 187.3,67.01 187.58,67.3 187.58,67.6 187.71,67.73 187.71,67.96 187.59,68.08 187.58,68.08 v2(187.58,68.09)
REM_DIODE4_N: length 16.6
  TOP w0.127: QE8.3 194.41,77.93 CE51.1 194.34,76.92 193.8,76.39 192.83,76.39 192.33,76.89 191.06,76.89 190.67,76.5 v4(190.67,74.65) 190.67,72.74 189.03,71.1 189.03,70.61 188.95,70.53 CE60.1 188.29,69.4 188.29,69.2 188.85,68.64 188.85,67.81 UE5.A16
REM_DIODE4_P: length 18.6
  TOP w0.127: UE5.B17 187.21,67.27 187.51,67.27 187.63,67.4 188.08,67.4 188.6,67.92 188.6,68.53 188.04,69.09 CE60.2 188.05,70.06 188.78,70.79 188.78,71.21 190.41,72.85 v4(190.41,73.23) 190.41,76.61 190.95,77.15 192.43,77.15 192.94,76.64 193.22,76.64 CE51.2 193.5,77.82 QE8.2 193.9,78.72 QE8.1
RESET_OUT#: length 160.8
  TOP w0.127: v2(175.09,67.45) 174.9,67.45 174.12,66.67 RE2.2 ; v2(179.59,65.55) 179.6,65.55 179.6,65.57 179.55,65.57 179.1,65.11 178.49,65.11 178.32,65.27 UE5.B39 ; RC129.1 65.79,76.84 v2(65.79,77.33)
  IN3 w0.089: v2(65.79,77.33) 64.38,75.92 62.94,75.92 62.5,75.48 62.5,73.9 62.85,73.56 63.61,73.56 65.84,75.79 69.66,75.79 70.26,75.19 70.26,74.79 70.77,74.27 74.18,74.27 75.12,75.22 78.6,75.22 80.31,73.51 90.07,73.51 90.52,73.96 91.96,73.96 92.63,74.63 99.33,74.63 102.33,71.64 106.42,71.64 108.26,73.48 110.07,73.48 110.2,73.62 111.55,73.62 112.43,74.5 119.2,74.5 119.45,74.25 121.96,74.25 122.28,74.58 122.28,75.49 122.67,75.87 123.9,75.87 124.23,76.21 129.52,76.21 130.33,77.02 130.33,77.6 130.56,77.83 139.88,77.83 140.78,76.93 145.46,76.93 145.81,76.57 151.57,76.57 152.92,75.22 153.29,75.22 153.95,75.22 154.17,75.01 156.71,75.01 v2(157.73,76.03)
  BOTTOM w0.127: UCPU1.B6 149.5,71.57 149.5,71.74 149.57,71.81 149.57,72.15 149.5,72.23 149.5,72.47 150.26,73.23 151.53,73.23 153.21,74.91 153.21,77.11 153.73,77.63 155.05,77.63 156.65,76.03 v2(157.73,76.03) v3(157.73,74.39) 157.73,73.4 158.77,72.36 159.5,72.36 161.17,70.69 164,70.69 164.39,71.08 165.09,71.08 166.79,72.78 167.88,72.78 168.27,72.39 168.27,71.82 168.78,71.31 174.28,71.31 175.24,70.34 175.24,68.25 175.06,68.07 175.06,67.48 v2(175.09,67.45) 175.12,67.42 175.68,67.42 175.93,67.67 177.26,67.67 178.51,66.42 179.36,66.42 179.63,66.16 179.63,65.6 v2(179.59,65.55)
RESET_OUT#_R: length 11.6
  TOP w0.127: v3(61.83,79.61) 61.83,78.61 62.38,78.06 63.76,78.06 64.04,77.78 64.87,77.78 65.36,77.28 65.36,76.32 RC128.2 RC129.2 CC33.1 67.04,75.56 67.04,74.56 67.1,74.51 JXDP1.47
RING2:
  vias: v2(8.06,24.39) v2(8.66,24.37) v2(28.36,34.11) v2(28.37,33.49)
RING2_R: length 4.2
  TOP w1.016: JHP1.4 4.45,25.51 5.4,24.56 5.4,22.73 5.82,22.31
  vias: v3(15.42,25.53)
RTD3_CIO_PWR_EN: length 249.8
  TOP w0.127: UT1.F1 39.74,55.46 39.74,55.07 39.85,54.96 39.85,54.33 40.44,53.74 RT39.2 40.02,53.05 40.02,52.17 39.99,52.14 39.99,51.51 40.43,51.07 v2(40.43,50.17) 39.55,50.17 37.73,51.99 RT26.2 ; v2(95.48,24.98) 95.63,25.13 95.63,25.64 95.34,25.93 94.99,25.93 94.73,25.67 89.36,25.67 88.88,26.15 v1(88.34,26.15) 87.94,26.15 86.87,27.22 86.87,27.56 86.22,28.22 83.09,28.22 82.12,27.24 82.12,26.6 80.64,25.12 79.7,25.12 79.32,25.49 79.32,26.48 78.89,26.91 69.93,26.91 v2(67.39,24.37)
  IN1 w0.081: v2(159.93,68.17) 159.93,67.69 160.21,67.41 160.21,66.89 159.15,65.83 159.15,64.3 157.72,62.87 157.72,62.11 156.16,60.55 156.16,55.59 v2(154.86,54.29)
  IN2 w0.089: v2(67.39,24.37) 64.92,24.37 61.27,20.71 51.58,20.71 51.04,20.18 39.45,20.18 37.9,21.73 37.34,21.73 37.1,21.96 37.1,22.97 37.44,23.31 37.44,30.95 38.53,32.04 38.53,34.58 38.86,34.91 38.86,36.25 39.19,36.58 39.19,36.97 38.94,37.22 38.41,37.22 38.01,37.61 38.01,39.31 38.39,39.69 38.39,40.69 39.13,41.43 39.13,46.71 39.85,47.43 39.85,49.59 v2(40.43,50.17) ; v2(154.86,54.29) 155.94,54.29 156.72,55.08 157.66,55.08 158.33,54.41 158.33,52.56 163.97,46.92 163.97,42.38 162.2,40.61 162.2,38.95 163.77,37.38 163.77,35.21 162.32,33.76 162.32,32.46 164.17,30.6 164.17,21.34 161.96,19.12 158.66,19.12 156.8,17.27 132.09,17.27 131.1,18.26 127.05,18.26 126.79,18 126.79,18 124.94,16.15 118.56,16.15 117.1,17.6 116.37,17.6 115.56,18.42 108.02,18.42 107.13,18.42 106,17.29 103.53,17.29 98.55,22.27 98.55,23.38 97.43,24.49 96.22,24.49 95.73,24.98 v2(95.48,24.98)
  BOTTOM w0.127: v2(159.93,68.17) 159.93,68.49 160.22,68.78 160.22,70.5 159.29,71.43 157.07,71.43 RC248.2
RTD3_USB_PWR_EN: length 8.9
  TOP w0.127: v2(38.93,56.94) 38.91,56.93 38.91,56.93 UT1.D4 ; v2(32.98,55.06) 32.98,55.79 RT40.2 33.86,55.97 RT52.2
  IN2 w0.089: v2(38.93,56.94) 37.56,55.58 36.44,55.58 36.12,55.25 33.18,55.25 v2(32.98,55.06)
RUN_ON: length 6.2
  TOP w0.127: UE5.B9 187.21,63.27 186.5,63.27 v2(186.41,63.19)
  BOTTOM w0.127: v3(190.4,63.46) 190.4,64.04 190.04,64.4 189.65,64.4 189.22,63.97 187.75,63.97 187.18,63.39 R250.2 187.14,63.19 v2(186.41,63.19)
RUN_ON#: length 4.9
  TOP w0.127: QE12.6 QE12.5 188.96,74.11 188.53,73.68 188.53,72.8 RE84.2 188.98,72.31 188.14,71.47 v3(188.14,71.05)
RUN_ON_EC: length 28.4
  TOP w0.127: QE12.2 187.55,74.11 187.09,74.11 186.77,74.43 186.77,75.62 v2(186.64,75.75)
  IN1 w0.081: v2(189.86,63.98) 191.93,63.98 192.01,64.06 192.56,64.06 v2(193.04,63.58)
  IN4 w0.081: v2(186.64,75.75) 186.64,74.76 184.77,72.9 184.77,72.16 190.09,66.84 190.09,64.21 v2(189.86,63.98)
  BOTTOM w0.127: v2(189.86,63.98) 189.29,63.41 R249.1 188.27,63.41 R250.1 ; UC10.2 191.45,59.65 191.95,60.15 191.95,60.62 191.66,60.91 191.66,61.51 191.81,61.66 192.29,61.66 RE98.2 193.04,62.42 v2(193.04,63.58) 193.04,63.99 v1(193.14,64.09)
RUN_ON_P: length 384.1
  TOP w0.127: v2(163.32,37.24) 163.32,37.24 163.04,36.96 163.04,36.04 161.97,34.97 161.97,32.65 162.53,32.09 PR611.1 163.04,32.55 v2(162.73,32.86) ; v2(178.28,80.48) 177.78,80.98 169.93,80.98 166.79,77.85 166.79,72.63 165.13,70.98 164.21,70.98 163.75,70.52 163.75,69.88 163.96,69.68 164.38,69.68 UC9.2 ; R1445.1 180.06,39.22 v2(179.52,39.76) ; v2(37.34,40.47) 37.33,40.48 U720.5 ; v2(179.49,42.18) 179.49,42.57 177.96,44.09 176.78,44.09 176.48,43.8 175.9,43.8 175.47,43.37 173.85,43.37 173.65,43.57 173.65,43.83 PR901.1 ; U719.3 52.23,19.75 52.95,19.03 53.52,19.03 R290.2 53.55,19.46 v2(53.14,19.46)
  IN2 w0.089: v2(97.94,23.4) 98.34,23.01 98.34,22.18 103.45,17.07 106.09,17.07 107.22,18.2 107.94,18.2 107.94,18.2 115.47,18.2 116.28,17.39 117.01,17.39 118.47,15.93 125.03,15.93 127.14,18.04 131.01,18.04 133.11,15.93 150.83,15.93 151.94,17.05 156.9,17.05 158.75,18.9 162.05,18.9 164.39,21.25 164.39,31.2 v2(162.73,32.86) ; v2(77.59,32.14) 78.85,32.14 81.53,29.45 81.53,25.89 80.75,25.1 79.5,25.1 79.32,25.28 75.7,25.28 74.05,23.63 65.48,23.63 64.69,22.84 64.69,22.08 64.24,21.62 63.33,21.62 61.98,20.28 55.22,20.28 54.74,19.8 53.48,19.8 v2(53.14,19.46)
  IN3 w0.089: v2(163.32,37.24) 163.89,37.81 166.17,37.81 166.7,38.34 170.79,38.34 171.41,38.97 173.75,38.97 174.04,38.67 180.06,38.67 181.32,39.93 181.32,42.73 180.49,43.56 179.34,43.56 176.93,45.97 176.93,48.85 177.66,49.58 177.66,50.79 178.14,51.27 178.14,51.68 179.23,52.77 181.37,52.77 181.9,52.24 187.53,52.24 189.44,54.16 189.44,57.85 191.9,60.31 192.48,60.31 193.77,61.6 v2(193.77,61.88) ; v2(97.94,23.4) 97.05,24.29 97.05,33.89 96.1,34.84 90.16,34.84 89.96,35.04 87.78,35.04 86.57,36.25 v2(86.57,36.52) ; v2(162.73,32.86) 162.03,32.86 160.62,34.27 160.62,37.39 162.49,39.25 163.61,39.25 164.18,38.68 165.81,38.68 166.39,39.25 170.48,39.25 171.06,39.83 173.63,39.83 174.35,40.55 176.54,40.55 177.52,39.57 179.33,39.57 v2(179.52,39.76) 179.79,39.76 180.31,40.28 180.31,41.65 179.77,42.18 v2(179.49,42.18)
  IN4 w0.081: v2(193.77,61.88) 193.77,61.88 193.14,61.24 193.14,61 192.71,60.58 191.97,60.58 191.67,60.88 191.55,61 191.55,64.59 192.16,65.19 193.49,65.19 194.3,66.01 194.3,66.42 195.24,67.35 196.21,67.35 198.04,69.19 198.04,73.99 196.54,75.49 193.04,75.49 191.41,77.12 185.27,77.12 184.79,76.64 182.12,76.64 v2(178.28,80.48) ; v2(77.59,32.14) 77.59,32.69 79.86,34.96 83.68,34.96 85.24,36.52 v2(86.57,36.52) ; v2(37.34,40.47) 37.92,41.06 38.94,41.06 39.27,40.73 39.27,40.34 38.81,39.89 38.2,39.89 36.14,37.82 36.14,35.93 37.91,34.16 37.91,32.98 39.6,31.29 39.6,27.96 41.27,26.28 41.27,25.09 40.23,24.05 40.23,22.88 41.25,21.87 41.25,21.06 41.6,20.7 41.94,20.7 43.68,18.96 45.43,18.96 46.49,17.9 48.74,17.9 49.54,18.7 52.38,18.7 v2(53.14,19.46)
  BOTTOM w0.127: v2(193.77,61.88) 193.7,61.81 193.07,61.81 192.89,61.63 RE98.1 192.89,61.33 193.68,60.54 194.46,60.54 RE99.1 194.49,59.9 193.6,59.9 UC10.4
RUNPWROK: length 10.6
  TOP w0.127: v2(183.06,67.17) 183.06,67.22 182.61,67.66 UE5.B26 ; v2(186.64,72.53) 186.56,72.6 RE83.2 186.66,73.46 187.55,73.46 QE12.3
  BOTTOM w0.127: v2(186.64,72.53) 186.77,72.4 v3(186.77,71.31) 185.32,69.86 184.59,69.86 184.05,69.32 183.54,69.32 182.93,68.71 182.93,67.29 v2(183.06,67.17)
SA_B+:
  vias: v2(67.49,61.32) v2(68.07,61.32) v2(68.68,61.35) v2(69.32,61.35) v3(70.17,62.52)
SA_SNUB: length 3.5
  BOTTOM w0.127: PR1086.2 71.64,66.34 v3(71.64,65.66)
  BOTTOM w0.508: PC1086.1 69.44,67.4 PR1086.2
SATA_PRX_SSDTX_N2: length 101.5
  IN4 w0.091: v2(134.34,69.81) 134.34,69.7 134.47,69.58 134.65,69.58 134.74,69.67 134.74,70.61 135.88,71.74 135.88,76.93 138.25,79.3 152.33,79.3 152.94,78.69 155.74,78.69 155.95,78.89 159.17,78.89 159.5,79.22 167.83,79.22 168.34,78.71 168.84,78.71 171.55,76 171.55,74.15 170.97,73.57 170.51,73.57 170.26,73.31 170.26,72.93 172,71.18 172,69.18 173.2,67.97 173.2,67.02 172.75,66.56 172.75,64.1 172.82,64.02 172.82,62.49 173.97,61.35 173.97,59.78 177.13,56.61 177.13,56.29 178.76,54.66 178.76,52.94 179.65,52.05 180.36,52.05 185.19,47.23 185.19,43.62 185.49,43.33 185.49,39.15 188.19,36.45 v2(188.19,32.95)
  BOTTOM w0.127: v2(134.34,69.81) 134.57,69.59 UCPU1.E30 ; v2(188.19,32.95) 188.05,33.09 188.05,33.34 187.76,33.64 186.9,33.64 R2664.1
SATA_PRX_SSDTX_N2_C: length 2.8
  BOTTOM w0.127: JNGFF2.43 183.89,33.79 184.04,33.65 185.07,33.65 185.18,33.55 185.43,33.55 R2664.2
SATA_PRX_SSDTX_P2: length 101.5
  IN4 w0.091: v2(187.58,32.95) 187.43,33.1 187.43,33.23 187.53,33.33 187.88,33.33 188,33.45 188,36.37 185.29,39.07 185.29,43.25 185,43.54 185,47.15 180.28,51.86 179.57,51.86 178.57,52.86 178.57,54.58 176.94,56.21 176.94,56.53 173.77,59.7 173.77,61.27 172.63,62.41 172.63,63.94 172.55,64.02 172.55,66.64 173.01,67.1 173.01,67.89 171.81,69.1 171.81,71.1 170.06,72.85 170.06,73.39 170.43,73.76 170.89,73.76 171.36,74.23 171.36,75.92 168.76,78.52 168.26,78.52 167.75,79.03 159.58,79.03 159.25,78.7 156.03,78.7 155.82,78.49 152.86,78.49 152.25,79.11 138.33,79.11 136.07,76.85 136.07,71.66 134.93,70.53 134.93,69.59 134.73,69.39 134.58,69.39 v2(134.37,69.18)
  BOTTOM w0.127: v2(134.37,69.18) 134.61,69.18 134.83,68.97 UCPU1.F30 ; v2(187.58,32.95) 187.65,32.95 187.8,33.1 187.8,33.24 187.65,33.38 186.76,33.38 186.67,33.29 R2663.1
SATA_PRX_SSDTX_P2_C: length 2.8
  BOTTOM w0.127: R2663.2 185.44,33.29 185.07,33.29 184.97,33.4 v4(184.69,33.4) 184.01,33.4 183.91,33.29 JNGFF2.41
SATA_PTX_SSDRX_N2: length 91.7
  IN4 w0.091: v2(187.33,34.98) 186.92,35.39 186.52,35.39 186.31,35.6 186.31,37.19 183.63,39.88 183.63,45.33 182.89,46.07 182.89,47.43 181.77,48.56 179.13,48.56 178.66,49.03 178.66,51.64 177.6,52.7 177.6,53.88 175.94,55.54 175.94,56.85 173.18,59.61 173.18,60.39 171.87,61.7 171.87,62.4 172.02,62.55 172.02,63.71 171.63,64.1 171.63,65.06 170.94,65.74 170.94,67.57 169.54,68.97 169.54,70.78 167.14,73.18 167.14,75.77 164.37,78.55 159.96,78.55 159.5,78.09 156.24,78.09 156.02,77.87 152.58,77.87 151.94,78.51 140.75,78.51 138.1,75.86 136.71,75.86 v2(136.5,75.65)
  BOTTOM w0.076: UCPU1.A25 137.65,72.31 137.73,72.24 137.73,72.1 137.62,71.99 137.36,71.99 137.3,72.05 137.3,72.14 137.24,72.42 137.24,72.92 136.72,73.44 136.29,73.44 135.81,73.92 135.81,74.13 135.85,74.18 135.85,74.2
  BOTTOM w0.127: 135.85,74.2 135.85,75.66 136.08,75.89 136.36,75.89 136.5,75.75 v2(136.5,75.65) ; v2(187.33,34.98) 187.13,35.18 186.96,35.18 CD47.1
SATA_PTX_SSDRX_N2_C: length 2.9
  BOTTOM w0.127: CD47.2 185.44,35.19 185.17,35.19 184.87,34.89 v4(184.61,34.89) 183.95,34.89 183.86,34.79 JNGFF2.47
SATA_PTX_SSDRX_P2: length 91.6
  IN4 w0.091: v2(187.33,35.65) 187.26,35.58 186.6,35.58 186.5,35.68 186.5,37.27 183.82,39.96 183.82,45.41 183.08,46.15 183.08,47.51 181.85,48.75 179.21,48.75 178.85,49.11 178.85,51.72 177.8,52.78 177.8,53.96 176.13,55.62 176.13,56.93 173.37,59.69 173.37,60.47 172.06,61.78 172.06,62.32 172.21,62.47 172.21,63.79 171.82,64.18 171.82,65.14 171.14,65.82 171.14,67.65 169.73,69.05 169.73,70.86 167.34,73.26 167.34,75.85 164.45,78.74 159.88,78.74 159.42,78.28 156.16,78.28 155.94,78.06 152.66,78.06 152.02,78.7 140.67,78.7 138.02,76.05 136.74,76.05 v2(136.5,76.29)
  BOTTOM w0.076: 135.6,74.2 135.6,74.18 135.64,74.13 135.64,73.85 136.22,73.28 136.65,73.28 137.07,72.85 137.07,72.41 137.13,72.13 137.13,71.98 137.32,71.79 UCPU1.B25
  BOTTOM w0.127: CD44.1 187,35.43 187.11,35.43 v2(187.33,35.65) ; 135.6,74.2 135.6,75.77 135.97,76.14 136.36,76.14 v2(136.5,76.29)
SATA_PTX_SSDRX_P2_C: length 2.9
  BOTTOM w0.127: CD44.2 185.43,35.45 185.06,35.45 184.76,35.14 184.07,35.14 183.92,35.29 JNGFF2.49
SD_PWR_EN: length 61.7
  TOP w0.127: U716.5 171.7,15.37 171.43,15.1 R1178.1 R1176.1 172.31,15.53 v2(172.26,15.58)
  IN3 w0.089: v2(161.23,14.79) 162.49,14.79 163.66,15.97 167.43,15.97 168.57,14.83 171.06,14.83 171.27,15.03 171.72,15.03 v2(172.26,15.58)
  IN4 w0.081: v2(162.76,33.49) 161.79,33.49 161.2,34.09 160.45,34.09 160.01,34.52 160.01,37.26 156.6,40.67 156.03,40.67 155.5,41.21 155.5,41.58 153.9,43.18 153.9,44.95 v2(154.15,45.19)
  BOTTOM w0.076: UCPU1.BA9 147.22,50.15 147.49,49.88 147.49,49.37 149,47.86 149.86,47.86 150.77,46.95 151.04,46.95 152.25,45.75
  BOTTOM w0.127: v2(162.76,33.49) 163.42,32.83 v3(163.42,31.66) 163.35,31.58 163.35,18.32 163.63,18.04 163.63,17.19 v2(161.23,14.79) ; v2(154.15,45.19) 153.59,45.75 152.25,45.75
