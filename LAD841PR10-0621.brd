# Allegro board LAD841PR10-0621.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FCCM_IA: length 27.1
  TOP w0.203: PU1000.21 70.76,56.46 71.05,56.75 71.65,56.75 v2(71.78,56.88)
  IN4 w0.203: v2(71.78,56.88) 72.21,57.31 78.21,57.31 80.44,59.54 80.44,63.28 79.05,64.68 78.84,64.68 78.11,65.41 v2(78.11,65.52)
  BOTTOM w0.254: PR1103.2 83.49,68.49 v3(83.13,68.49) 78.88,68.49 78.11,67.71 78.11,65.54 78.08,65.52 v2(78.11,65.52)
FCCM_VSA: length 16.3
  TOP w0.203: v2(61.95,58.2) 61.48,58.67 61.48,59.1 60.63,59.95 60.63,61.48 60.87,61.72 60.87,63.62 60.66,63.84 60.66,64.78 61.11,65.24 PR1059.2 ; v2(66.66,57.55) 67.11,57.11 67.11,57.06 67.56,56.6 67.56,56.11 PU1000.29
  IN3 w0.203: v2(66.66,57.55) 66.02,58.2 64.29,58.2 64,58.49 62.7,58.49 62.41,58.2 v2(61.95,58.2)
FIVR_EN: length 3.4
  TOP w0.127: v3(73.95,80.53) 74.26,80.22 74.26,79.75 RC219.2
  TOP w0.254: RC218.2 73.99,79.36 RC219.2 75.51,79.36 RC217.1
FIVR_EN_R: length 17.7
  TOP w0.127: v2(67.63,74.75) 67.6,74.72 JXDP1.45 ; RC217.2 RC132.2 76.43,76.95 RC126.2 75.86,77.26 v2(75.86,77.58)
  IN1 w0.081: v2(67.63,74.75) 68.13,75.26 68.13,75.66 68.63,76.15 69.76,76.15 70.24,76.64 74.91,76.64 v2(75.86,77.58)
  BOTTOM w0.127: v3(67.13,72.09) 67.63,72.59 v2(67.63,74.75)
FWP#: length 9.8
  TOP w0.127: UE5.B65 185.11,58.9 184.91,59.1 184.91,59.47 185.32,59.87 v2(185.45,59.87)
  BOTTOM w0.127: v2(185.45,59.87) 185.34,59.87 184.91,59.45 184.91,59.11 185.35,58.67 186.38,58.67 187.44,57.62 188.14,57.62 RE82.2 188.85,58.12 189.51,57.47 RE81.2 189.51,56.22 v3(189.33,56.05)
GPP_B22: length 2.3
  TOP w0.127: v3(148.77,55.68) 148.93,55.53 v2(148.93,55.1) 149.34,54.7 RC184.2
  BOTTOM w0.127: UCPU1.AN5 149.22,55.4 v2(148.93,55.1)
GPP_B23: length 4.4
  TOP w0.127: RC26.1 149.23,56.11 148.55,56.11 v2(148.08,55.64) 146.92,54.48 v3(146.83,54.48)
  BOTTOM w0.076: UCPU1.AM7 148.49,56.05 v2(148.08,55.64)
GPP_C5: length 3.7
  BOTTOM w0.076: UCPU1.W1 153.21,62.17
  BOTTOM w0.127: RC25.1 155.44,62.17 v3(154.23,62.17) 153.21,62.17
GPP_E1: length 2.1
  TOP w0.127: RC51.1 150.72,68.35 v1(150.44,68.63) 150.32,68.63 v2(150.03,68.33)
  BOTTOM w0.127: v2(150.03,68.33) 150.22,68.14 UCPU1.H3
GT1N: length 25.4
  TOP w0.254: v2(74.14,48.41) 74.14,47.84 74.65,47.33 v2(75.54,47.33)
  IN2 w0.203: v2(90.73,47.33) 90.5,47.1 90.5,46.49 89.94,45.93 85.74,45.93 84.35,47.32 84.35,49.08 83.69,49.74 82.01,49.74 81.07,50.68 79.63,50.68 76.45,47.51 75.72,47.51 v2(75.54,47.33)
  BOTTOM w0.203: PR1135.2 v2(90.73,47.33)
  BOTTOM w0.254: PR1115.1 75.11,46.9 v2(75.54,47.33) ; v2(74.14,48.41) 74.14,48.47 73.7,48.92 PR1112.1
GT1P: length 23.1
  IN2 w0.203: v2(89.99,47.33) 90.17,47.15 90.17,46.63 89.81,46.26 85.88,46.26 84.68,47.46 84.68,49.22 83.83,50.07 82.14,50.07 81.2,51.01 79.49,51.01 76.32,47.84 75.72,47.84 v2(75.59,47.96)
  BOTTOM w0.203: PR1134.2 v2(89.99,47.33)
  BOTTOM w0.254: v2(75.59,47.96) PR1116.2 74.59,47.96 73.64,47.01 PR1118.1
GT2N: length 23.2
  IN4 w0.203: v2(90.91,54.95) 90.58,54.62 90.58,54.14 89.92,53.48 81.98,53.48 77.46,48.95 76.78,48.95 v2(76.56,48.73)
  BOTTOM w0.254: PR1120.2 75.29,45.11 v3(76.34,46.16) 76.81,46.63 76.81,47.53 PR1107.1 76.24,48.41 v2(76.56,48.73) ; PR1133.2 v2(90.91,54.95)
GT2P: length 19.4
  IN4 w0.203: v2(89.89,54.95) 90.25,54.59 90.25,54.27 89.78,53.81 81.84,53.81 77.33,49.3 76.62,49.3 v2(76.56,49.36)
  BOTTOM w0.203: PR1132.2 v2(89.89,54.95)
  BOTTOM w0.254: v2(76.56,49.36) 76.3,49.36 76.05,49.11 PR1111.2 75.59,49.03 PR1109.1
GT_SNUB1: length 4.2
  TOP w0.127: PC1130.1 85.07,45.61 85.07,44.92 v3(86.07,43.91)
  TOP w0.508: PC1130.1 85.57,46.12 PR1114.2
GT_SNUB2: length 3.6
  TOP w0.127: v3(85.26,51.65) PC1125.1
  TOP w0.508: PC1125.1 85.32,53.74 PR1106.2
GT_SW1:
  vias: v2(85.61,48.01) v2(85.57,45.04) v2(86.72,44.79) v2(86.97,49.74) v2(88.11,49.74) v2(88.11,44.79) v2(89,48.6) v2(89,45.3) v3(88.88,47.58)
GT_SW2:
  vias: v2(85.57,55.58) v2(85.57,54.7) v2(85.95,52.66) v2(87.22,52.66) v2(87.35,57.36) v2(88.62,52.66) v2(89,57.24) v2(89,56.09) v3(88.62,53.55)
H_CATERR#: length 7.8
  BOTTOM w0.076: UCPU1.D63 116.6,70.58 116.6,70.69 116.67,70.96 116.67,71.07 116.7,71.18 116.8,71.5 116.81,71.55 116.81,71.8 116.78,71.89 116.78,72.08 116.81,72.18 116.81,72.54 116.66,72.69 116.66,73.06 117.04,73.44 117.04,74.17 116.77,74.45 v1(116.73,74.45) 116.54,74.45 116.02,74.96 116.02,75.9 116.54,76.41
  BOTTOM w0.127: RC79.2 116.54,76.41
H_CPU_SVIDALRT#: length 13.4
  BOTTOM w0.076: UCPU1.B63 116.05,71.99 116.05,73.28 116.05,73.28 116.05,73.39 116.37,73.71 116.37,73.83 116.28,73.92 116.16,73.92 115.84,73.6 115.73,73.6 115.62,73.71 115.62,73.82 115.96,74.15 115.96,74.28 115.87,74.37 115.74,74.37 115.41,74.03 115.3,74.03 115.19,74.14 115.19,74.25 115.5,74.56 115.5,74.68 115.37,74.81 115.21,74.81 v3(115.07,74.67) 114.9,74.51 114.82,74.51 114.72,74.61 114.7,74.61 114.62,74.68 114.62,75.05 114.52,75.15 114.4,75.15 114.32,75.07 114.32,74.68 114.24,74.61 113.23,74.61 113.18,74.66 113.18,74.92 113.26,75 113.86,75 114.19,75.33 114.19,75.56 114.44,75.82 114.88,75.82 114.96,75.9 114.96,76.55 115.07,76.66 115.34,76.66 115.42,76.58 RC153.1
H_CPUPWRGD: length 8.5
  TOP w0.127: CA35.1 RC77.2 110.48,73.66 109.45,73.66 v2(109.22,73.89) 109.07,74.04 v1(109.07,74.76)
  BOTTOM w0.076: v2(109.22,73.89) 110.23,72.88 112.68,72.88 UCPU1.A68
H_CPUPWRGD_R: length 1.1
  TOP w0.127: T9.1 109.25,73.19 RC77.1
H_PROCHOT#: length 196.5
  TOP w0.127: RC84.1 RC83.2 111.42,75.59 v2(111.51,75.5) ; PR1124.1 61.44,51.04 PC1006.2 61.29,51.01 60.76,51.54 v2(60.76,51.72) ; RE96.2 172.39,60.16 v2(172.09,59.85)
  IN2 w0.089: v2(172.09,59.85) 171.86,60.08 165.91,60.08 v2(165.18,60.82)
  IN3 w0.089: v2(60.76,51.72) 60.76,51.24 59.85,50.33 55.71,50.33 55.22,49.84 53.11,49.84 52.6,49.34 52.6,47.71 51.4,46.51 51.4,45.05 52.28,44.16 52.28,39.26 51.21,38.19 51.21,33.56 48.64,31 46.48,31 45.11,29.63 44.51,29.63 43.22,30.92 39.85,30.92 39.19,30.26 38.66,30.26 38.46,30.06 37.49,30.06 36.94,29.51 v2(36.94,28.52)
  IN4 w0.081: v2(60.76,51.72) 62.42,53.39 62.42,56.02 62.87,56.46 63.54,56.46 64.57,57.49 64.57,58.43 64.25,58.74 64.25,61.11 65.79,62.65 65.79,65.64 69.24,69.1 69.24,70.57 71.55,72.88 79.5,72.88 80.08,72.3 91.82,72.3 92.18,71.94 97.45,71.94 97.81,71.58 98.86,71.58 99.67,70.77 105.25,70.77 105.61,71.14 105.95,71.14 108.67,73.85 108.67,73.99 109.76,75.08 111.09,75.08 v2(111.51,75.5) 113.51,73.49 117.58,73.49 119.71,71.36 119.94,71.36 120.5,70.8 120.93,70.8 122.4,69.33 122.4,68.41 125.03,65.78 126.82,65.78 127.68,64.93 127.68,64.42 128.47,63.63 140.84,63.63 141.53,64.32 142.06,64.32 142.09,64.35 145.57,64.35 146.2,64.98 146.2,66.1 146.41,66.3 149.2,66.3 150.15,65.36 153.18,65.36 154.45,66.63 158.97,66.63 162.69,62.91 162.69,62.2 164.08,60.82 v2(165.18,60.82)
  BOTTOM w0.127: PR405.2 168.04,58.72 168.04,59.53 v3(167.79,59.77) 166.65,60.92 165.28,60.92 v2(165.18,60.82) ; PR316.1 36.73,28.74 v2(36.94,28.52)
H_PROCHOT#_EC: length 3.7
  TOP w0.127: RE96.1 174.68,59.57 v3(175.13,59.57) 175.21,59.65 175.9,59.65 176.78,60.52 177.16,60.52 UE5.A46
H_PROCHOT#_R: length 10.8
  TOP w0.127: v2(112.75,75.5) 113.02,75.77 113.02,76.34 RC84.2 112.31,77.47 112.45,77.61 v3(112.45,78.26)
  BOTTOM w0.076: v2(112.75,75.5) 112.62,75.5 112.12,74.99 112.12,74.53 112.55,74.1 114.53,74.1 115.55,73.08 115.55,71.52 115.25,71.22 UCPU1.C65
H_THERMTRIP#: length 80.3
  TOP w0.127: RC80.2 115.29,75.59 v2(115.47,75.42) ; QE9.3 174.46,70.54 172.84,68.93 172.05,68.93 171.2,69.78 v2(170.17,69.78)
  IN3 w0.089: v2(153.62,67.48) 153.66,67.45 155.12,67.45 156.35,68.67 156.35,70.13 157.48,71.26 160.06,71.26 160.78,70.54 169.4,70.54 v2(170.17,69.78)
  IN4 w0.081: v2(153.62,67.48) 152.77,68.33 151.97,68.33 151.52,67.89 149.09,67.89 148.59,68.39 148.59,68.79 147.47,69.91 146.28,69.91 145.69,69.33 145.69,67.22 145.42,66.94 141.61,66.94 139.83,65.16 135.07,65.16 133.21,67.03 127.27,67.03 125.67,67.03 125.3,67.4 125.24,67.4 124.6,68.04 124.18,68.04 123.8,68.42 123.8,70.19 122.39,71.59 121.12,71.59 120.49,72.23 120.49,73.26 119.47,74.28 118.08,74.28 117.65,74.71 116.18,74.71 v2(115.47,75.42)
  BOTTOM w0.076: UCPU1.C63 116.52,71.16 116.52,71.25 116.56,71.32 116.65,71.57 116.65,71.75 116.59,71.94 116.59,72.09 116.65,72.21 116.65,72.47 116.49,72.62 116.49,73.13 116.88,73.51 116.88,73.83 115.47,75.25 v2(115.47,75.42)
H_VCCST_PWRGD: length 36.2
  TOP w0.127: UE5.A44 176.23,61.52 v2(176.2,61.49)
  IN1 w0.081: v2(176.2,61.49) 177.99,61.49 178.24,61.74 179.93,61.74 182.31,64.12 184.07,64.12 184.65,64.69 189.47,64.69 189.53,64.76 190.09,64.76 190.4,65.07 190.56,65.23 192.7,65.23 192.76,65.17 193.6,65.17 193.83,65.41 193.83,67.16 v2(193.62,67.37)
  BOTTOM w0.127: U729.2 188.48,77.19 188.31,77.02 188.31,75.51 RE94.2 188.78,75.49 188.83,75.54 RE93.1 189.84,74.91 189.84,74.29 191.3,72.84 v1(191.3,72.1) 191.91,71.49 192.46,71.49 193.28,70.67 193.28,67.71 v2(193.62,67.37)
H_VCCST_PWRGD_P: length 152.2
  TOP w0.127: RC123.1 71.63,74.96 v2(72.42,74.96)
  IN2 w0.089: v2(154,67.01) 155.04,67.01 156.39,68.37 157.93,68.37 158.31,67.98 158.31,67.14 159.97,65.48 161.31,65.48 161.73,65.06 162.82,65.06 163.24,65.48 166.07,65.48 166.63,64.91 167.79,64.91 168.02,65.15 171.65,65.15 171.76,65.04 174.39,65.04 174.47,65.12 175.34,65.12 175.67,64.78 177.16,64.78 178.36,63.59 178.79,63.59 179.33,63.04 v2(179.71,63.04)
  IN4 w0.081: v2(154,67.01) 153.37,67.01 153.09,67.29 149,67.29 148.39,66.69 146.25,66.69 145.84,66.28 145.03,66.28 144.8,66.05 144.8,65.72 144.83,65.69 144.83,65.41 144.6,65.19 140.87,65.19 140.03,64.35 139.28,64.35 139.13,64.5 136.5,64.5 136.02,64.02 128.63,64.02 128.06,64.58 128.06,65.09 126.97,66.18 125.27,66.18 124.71,66.73 124.71,67.37 124.44,67.65 123.71,67.65 122.79,68.57 122.79,70.59 122.18,71.21 120.63,71.21 120.1,71.74 120.09,71.74 119.03,72.81 119.03,73.36 118.5,73.89 113.72,73.89 v2(112.12,75.5) 111.56,76.06 111.22,76.06 110.89,76.39 108.62,76.39 106.96,74.73 106.96,73.53 105.55,72.12 105.18,72.12 104.84,71.78 100.32,71.78 98.74,73.36 95.76,73.36 94.93,74.2 87.64,74.2 87.26,73.82 82.77,73.82 82.62,73.97 80.08,73.97 78.01,76.04 73.23,76.04 72.42,75.22 v2(72.42,74.96)
  BOTTOM w0.127: U729.4 187.42,75.51 RE94.1 187.41,74.43 188.43,73.4 188.43,71.89 186.72,70.17 186.72,69.34 186.3,68.92 184.49,68.92 184.37,69.04 183.81,69.04 183.49,68.72 183.49,65.58 182.9,64.99 v3(181.91,64.99) 181.24,64.99 179.71,63.47 v2(179.71,63.04) ; RC71.2 112.6,77.91 112.29,77.61 112.29,76.51 CA32.1 ; CA32.1 111.86,76.11 RC78.1 ; CA32.1 111.86,75.75 v2(112.12,75.5)
H_VCCST_PWRGD_XDP: length 6
  TOP w0.127: RC124.2 71.6,75.9 RC123.2 70.18,76.26 v1(70.18,74.89) 70.03,74.74 69.57,74.74 69.1,74.26 JXDP1.39
HDA_AUDIO_PD#: length 4.1
  TOP w0.127: v3(32.22,24.77) 31.99,25 RA59.2 31.22,25.69 30.88,26.03 29.69,26.03 29.46,26.26 29.46,26.48 UA2.47
HDA_BIT_CLK: length 6.3
  BOTTOM w0.076: UCPU1.AY22 139.96,50.83 139.85,50.72 139.75,50.61 139.68,50.4 139.68,50.28 139.75,50.05 139.75,49.91 139.69,49.79 139.69,49.53 139.99,49.22 139.99,48.73 139.8,48.54 139.8,48.13 139.98,47.95 139.98,47.27 v3(140.21,47.05) 140.57,46.68
  BOTTOM w0.127: 140.57,46.68 140.82,46.44 RC93.2
HDA_BIT_CLK_R: length 137.6
  TOP w0.127: UA2.6 32.01,29.48 32.72,30.18 CA30.2 33.55,30.69 36.08,30.69 38.02,28.75 38.02,27.92 38.55,27.39 v2(38.62,27.39)
  IN2 w0.089: v2(80.06,27.92) 79.78,27.64 77.75,27.64 76.96,26.86 65,26.86 61.85,23.71 59.33,23.71 58.57,22.95 56.19,22.95 55.09,24.04 53.19,24.04 50.95,26.27 44.04,26.27 42.95,27.36 38.67,27.36 38.64,27.39 v2(38.62,27.39)
  BOTTOM w0.127: RC93.1 CC27.1 141.71,44.21 142.57,43.34 142.57,42.32 142.22,41.97 138.86,41.97 136.47,39.58 118.29,39.58 117.68,40.19 107.14,40.19 v3(106.91,40.42) 106.1,40.42 103.53,37.85 100.46,37.85 96.92,34.32 96.92,32.26 96.21,31.55 96.21,30.84 94.43,29.05 92.98,29.05 92.18,28.25 92.18,25.38 91.88,25.09 90.45,25.09 89.2,23.85 87.69,23.85 87.68,23.83 82.75,23.83 82.35,24.24 80.03,24.24 79.47,24.8 79.47,27.33 v2(80.06,27.92)
HDA_SDIN0: length 141.8
  TOP w0.127: v2(38.55,28.78) 38.54,28.79 38.35,28.79 35.71,31.43 34.19,31.43 RA62.1
  IN2 w0.089: v2(38.55,28.78) 38.56,28.79 38.9,28.79 39.14,28.54 39.14,28.03 38.91,27.79 38.23,27.79 38.09,27.65 38.09,27.16 38.29,26.96 39.75,26.96 40.09,26.62 42.2,26.62 42.93,25.89 50.32,25.89 52.97,23.24 53.28,23.24 53.85,22.67 55.09,22.67 55.89,21.87 61.09,21.87 65.41,26.18 77.58,26.18 78.49,27.09 79.81,27.09 80.49,27.77 80.49,28.23 v2(80.24,28.48)
  IN4 w0.081: v2(80.24,28.48) 80.39,28.48 80.97,29.06 81.32,29.06 81.63,28.75 87.11,28.75 89.08,30.72 91.33,30.72 91.61,30.45 91.98,30.45 94.36,28.07 94.36,27.53 v2(94.56,27.32)
  BOTTOM w0.127: UCPU1.BA21 140.34,50.48 140.34,49.5 140.65,49.19 140.65,48.04 140.5,47.89 140.5,47.31 140.6,47.21 140.6,47.14 140.98,46.76 141.96,46.76 142.21,46.51 142.21,44.16 142.84,43.53 142.84,42.22 142.29,41.68 139.06,41.68 136.49,39.12 118.35,39.12 117.55,39.92 105.96,39.92 103.64,37.6 100.56,37.6 97.17,34.21 97.17,32.15 96.46,31.44 96.46,28.99 94.8,27.32 v2(94.56,27.32)
HDA_SDIN0_R: length 2.7
  TOP w0.127: RA62.2 32.88,31.2 32.28,30.59 v3(31.85,30.59) 31.51,30.59 31.19,30.28 UA2.8
HDA_SDOUT: length 26
  TOP w0.127: RH24.2 157.79,50.25 157.22,49.68 156.01,49.68 155.32,50.38 154.2,50.38 v2(153.75,49.92) ; RC187.2 140.84,46.21 RC94.2 139.98,48.01 v2(140.23,48.27)
  IN3 w0.089: v2(153.75,49.92) 152.52,48.69 148.56,48.69 147.35,47.48 147.35,46.77 145.97,45.4 143.69,45.4 140.82,48.27 v2(140.23,48.27)
  BOTTOM w0.076: UCPU1.BB22 139.96,49.54 140.18,49.31 140.18,48.32 v2(140.23,48.27)
HDA_SDOUT_R: length 138.8
  TOP w0.127: v2(139.85,40.5) 139.07,41.28 RC94.1 ; v2(38.95,26.51) 38.9,26.51 38.1,27.3 38.1,27.42 37.77,27.75 37.77,28.65 36.36,30.06 35.1,30.06 34.75,29.7 33.58,29.7 CA27.2 32.95,29.08 UA2.5
  IN2 w0.089: v2(38.95,26.51) 39.05,26.4 42.11,26.4 42.84,25.68 50.23,25.68 52.88,23.02 53.19,23.02 54.56,21.65 61.18,21.65 65.5,25.97 77.67,25.97 78.58,26.87 79.9,26.87 80.71,27.68 80.71,28.8 v2(80.21,29.3)
  IN4 w0.081: v2(80.21,29.3) 80.39,29.47 81.5,29.47 81.8,29.17 83.89,29.17 85.86,31.14 91.51,31.14 91.78,30.87 92.15,30.87 95.7,27.32 95.7,26.85 v2(95.23,26.37)
  BOTTOM w0.127: v2(95.23,26.37) 97.26,28.41 97.26,31.16 97.96,31.85 97.96,33.08 98.33,33.45 99.18,33.45 99.74,34 99.74,34.32 102.2,36.78 103.94,36.78 106.3,39.15 116.93,39.15 117.99,38.09 137.45,38.09 v3(137.96,38.6) v2(139.85,40.5)
HDA_SYNC: length 8.4
  BOTTOM w0.076: UCPU1.BA22 139.96,50.55 140.37,50.96 140.7,50.96 140.83,50.84 140.83,50.28 140.68,50.14 140.68,49.46 140.84,49.3 140.84,47.93 140.69,47.78 140.69,47.39 140.79,47.29 140.79,47.25 141.01,47.03 141.37,47.03 141.51,47.17 v3(141.68,47.17) 141.91,47.17 142.72,46.35 RC92.2
HDA_SYNC_R: length 153.4
  TOP w0.127: v2(38.4,29.62) 38.09,29.62 35.13,32.57 33.53,32.57 CA24.2 32.09,32.09 31.08,31.08 UA2.10
  IN4 w0.081: v2(38.4,29.62) 38.04,29.26 38.04,27.16 38.26,26.94 39.35,26.94 39.83,26.46 39.83,25.56 38.59,24.32 38.59,20.75 39.24,20.1 39.62,20.1 39.85,19.87 41.17,19.87 41.66,19.37 41.66,18 42.98,16.68 49.79,16.68 51.27,18.15 52.88,18.15 54.78,20.06 55.87,20.06 58.95,16.97 62.99,16.97 63.84,17.82 67.17,17.82 75.23,25.89 75.76,25.89 78.56,28.69 v2(78.87,28.69)
  BOTTOM w0.127: v2(78.87,28.69) 79.22,28.34 79.22,24.69 79.98,23.93 82.2,23.93 82.55,23.58 87.78,23.58 87.8,23.6 89.31,23.6 90.55,24.84 93.43,24.84 93.83,25.23 93.83,26.36 94.22,26.76 94.59,26.76 96.72,28.88 96.72,31.34 97.45,32.07 97.45,33.45 98.76,34.76 99.45,34.76 101.99,37.29 103.73,37.29 106.09,39.66 117.42,39.66 118.35,38.72 136.58,38.72 139.18,41.32 142.47,41.32 143.26,42.11 143.26,44 RC92.1
HOST_DEBUG_TX: length 12.4
  TOP w0.127: v2(179.74,64.42) 179.74,63.67 179.25,63.18 179.25,62.92 178.97,62.64 178.54,62.64 178.41,62.77 178.01,62.77 UE5.B44
  BOTTOM w0.127: JDEG1.8 173.15,67.85 174.55,66.46 174.7,66.46 175.29,65.87 175.88,66.46 177.34,66.46 177.93,65.87 177.93,65.23 178.31,64.84 179.32,64.84 v2(179.74,64.42)
HOST_SD_WP#: length 81.3
  IN4 w0.081: v2(157.28,59.65) 158.5,58.43 158.5,57.77 159.19,57.08 159.19,52.67 166.69,45.17 166.69,44.65 167.3,44.04 167.3,43.49 166.89,43.08 166.89,39.31 170.05,36.15 170.05,31.18 173.33,27.9 173.33,26.77 175.41,24.68 175.41,21.38 178.33,18.46 186.46,18.46 186.91,18 193.56,18 193.66,18.11 196.78,18.11 197.91,16.98 198.81,16.98 v2(199.52,16.26)
  BOTTOM w0.127: UCPU1.AB3 151.15,60.51 152.3,60.51 152.45,60.66 154.22,60.66 154.73,60.16 155.47,60.16 RC292.2 156.15,59.48 157.11,59.48 v2(157.28,59.65) 157.41,59.65 v3(157.94,59.12) ; v2(199.52,16.26) 199.41,16.16 JIO1.37
HP2_D_L: length 10.9
  TOP w0.203: UA2.32 23.66,29.08
  TOP w0.381: 23.66,29.08 23.22,29.08 23.14,29.15 22.24,29.15 v1(21.85,28.76) 21.54,28.44 20.63,28.44 20.32,28.14 20.32,26.16 19.82,25.66 RA50.2 19.34,25.66 v2(19.04,25.37)
  BOTTOM w0.381: RA50.2 19.71,25.61 RA17.1 ; RA50.2 RA48.2 ; RA50.2 19.34,25.66 v2(19.04,25.37)
HP2_D_L_C: length 15.1
  TOP w0.127: JHP1.1 13.16,25.51 14.25,26.6 v3(14.25,27.14)
  IN4 w0.381: v2(17.65,26.86) 15.62,26.86 14.28,25.51 JHP1.1
  BOTTOM w0.305: LA7.2 20.57,23.03 19.79,23.81 CA29.2
  BOTTOM w0.381: CA29.2 19.56,23.81 18.21,25.15 DA2.3 17.65,26.45 v2(17.65,26.86)
HP2_D_L_R1: length 2.5
  BOTTOM w0.127: v3(21.46,25.97) 21.46,25.71 20.63,24.87 RA17.2
  BOTTOM w0.381: LA7.1 20.68,24.67 RA17.2
HP2_D_R: length 12
  TOP w0.203: 23.35,28.6 23.77,28.6 23.84,28.68 24.61,28.68 UA2.33
  TOP w0.381: 23.35,28.6 v2(22.66,28.6)
  BOTTOM w0.254: v2(22.66,28.6) 22.66,29.7 22.11,30.25 v3(21.85,30.25) 20.4,30.25 19.91,29.76 19.91,28.43 19.11,27.63 RA51.2 RA49.2 RA60.1 16.64,27.59 RA15.1
HP2_D_R_C: length 24.6
  IN1 w0.254: JHP1.2 7.34,36.03 13.97,36.03 14.4,35.59 14.4,34.76 14.86,34.3 14.86,25.18 v2(14.15,24.47)
  BOTTOM w0.254: CA69.1 15.29,24.16 16.28,25.15 DA2.2 ; CA69.1 LA6.2 ; CA69.1 14.45,24.16 v2(14.15,24.47)
HP2_D_R_R2: length 5
  BOTTOM w0.127: v3(13.18,23.6) 13.18,24.71 14.38,25.91 LA6.1
  BOTTOM w0.254: RA15.2 14.83,27.54 LA6.1
I2C0_SCK_EDP: length 26.5
  TOP w0.127: R291.2 199.89,27.71 v2(201.65,27.71) 202.12,27.71 202.98,28.56 U48.7 ; v2(192.51,23.76) 192.51,24.46 190.14,26.82 190.14,29.46 v2(190.44,29.76)
  IN1 w0.081: v2(190.44,29.76) 190.57,29.89 195.58,29.89 197.76,27.71 v2(201.65,27.71)
  BOTTOM w0.127: R287.2 190.03,28.79 190.44,29.2 v2(190.44,29.76) ; v2(192.51,23.76) 192.75,24.01 JEDP.1
I2C0_SCK_EDP_PCH: length 107.6
  TOP w0.127: v2(195.17,28.28) v3(196.89,28.28) 198.4,28.28 R291.1
  IN2 w0.089: v2(149.09,62.62) 149.72,62.62 151.83,60.51 151.83,58.54 152.36,58.01 152.36,56.9 152.75,56.5 154.48,56.5 154.71,56.28 156.26,56.28 156.66,55.88 157.47,55.88 158.76,54.59 158.76,52.74 164.4,47.1 164.4,41.58 163.56,40.74 163.56,39.44 164.7,38.29 v2(164.7,36.34)
  IN3 w0.089: v2(164.7,36.34) 165.19,35.85 165.19,34.83 165.47,34.55 165.47,30.14 164.63,29.31 164.63,26.69 163.85,25.91 163.85,23.55 161.72,21.41 158.7,18.4 158.7,16.28 159.55,15.43 162.27,15.43 163.42,16.58 177.62,16.58 180.16,19.12 185.08,19.12 186.05,20.08 189.51,20.08 195.17,25.74 v2(195.17,28.28)
  BOTTOM w0.127: v2(149.09,62.62) 149.39,62.92 UCPU1.U6
I2C0_SDA_EDP: length 20.6
  TOP w0.127: U48.6 203.63,28.65 v2(201.64,26.66) 201.48,26.5 v3(200.84,26.5) R292.2
  IN1 w0.081: v2(190.79,27.24) 197.73,27.24 198.3,26.66 v2(201.64,26.66)
  BOTTOM w0.127: R288.2 190.13,27.9 v2(190.79,27.24) 191.16,26.87 192.75,26.87 JEDP.6
I2C0_SDA_EDP_PCH: length 107.4
  TOP w0.127: R292.1 198.62,26.34 v2(198.06,26.34)
  IN2 w0.089: v2(164.7,35.69) 164.3,36.09 164.3,38.39 163.34,39.35 163.34,40.83 164.18,41.67 164.18,47.01 158.54,52.65 158.54,54.5 157.38,55.66 156.57,55.66 156.17,56.07 154.62,56.07 154.4,56.29 152.66,56.29 152.15,56.81 152.15,57.92 151.61,58.45 151.61,60.42 149.87,62.16 148.9,62.16 v2(148.42,62.64)
  IN3 w0.089: v2(164.7,35.69) 164.71,35.69 164.93,35.47 164.93,34.7 165.25,34.39 165.25,30.3 164.31,29.37 164.31,26.7 163.62,26.01 163.62,23.64 161.62,21.64 158.46,18.48 158.46,16.18 159.48,15.15 159.48,14.96 159.83,14.61 160.35,14.61 160.95,15.21 162.41,15.21 163.52,16.32 177.72,16.32 180.3,18.9 185.22,18.9 186.11,19.79 189.58,19.79 195.92,26.12 197.85,26.12 v2(198.06,26.34)
  BOTTOM w0.127: v3(164.02,35.69) 164.7,35.69 v2(164.7,35.69) ; v2(148.42,62.64) 148.74,62.96 UCPU1.U7
I2C1_SCK: length 15.4
  TOP w0.127: v2(185.04,17.81) 185.06,17.79 MD10.3 185.29,16.65 188.34,13.6 v3(188.54,13.6) 188.67,13.47 190.4,13.47 R1105.1 191.06,14.06 RH456.2 192.63,15.63 192.63,16.34 192.22,16.75 191.84,16.75 191.62,16.97 QH7.4
  BOTTOM w0.127: JTP1.3 185.66,19.36 185.66,18.43 v2(185.04,17.81)
I2C1_SCK_TP: length 89
  TOP w0.127: v2(190.96,16.04) RH456.1 191.16,15.07 QH7.3
  IN4 w0.081: v2(191.49,18.93) 191.25,18.69 187.19,18.69 186.74,19.14 182.04,19.14 179.02,22.16 179.02,25.31 174.42,29.9 174.17,29.9 173.1,30.98 173.1,31.55 172.59,32.06 172.59,36.97 171.89,37.67 171.89,39.94 170.28,41.54 170.28,43.09 169.71,43.66 169.71,44.95 165.99,48.67 165.34,48.67 164.93,49.07 164.93,50.15 166.25,51.47 166.25,55.51 163.9,57.86 163.9,59.43 163.51,59.82 162.77,59.82 161.83,60.76 v2(161.83,61.81) 161.83,62.56 160.52,63.87 159.55,63.87 158.57,64.86 157.01,64.86 156.65,65.22 154.24,65.22 153.47,64.45 147.68,64.45 v2(147.1,63.88)
  BOTTOM w0.076: v2(147.1,63.88) 147.1,63.61 147.44,63.28 UCPU1.U9
  BOTTOM w0.127: v2(191.49,18.93) 190.96,18.4 v2(190.96,16.04) ; RC285.2 159.89,60.74 160.77,60.74 v3(161.25,61.23) v2(161.83,61.81)
I2C1_SDA: length 11.8
  TOP w0.127: MD10.2 188.47,16.65 RH461.2 189.71,17.89 R1104.1 v3(189.71,19.39) ; MD10.2 187,15.6 187.33,15.26 189.52,15.26 QH7.1 ; MD10.2 187,17.31 v2(186.59,17.71)
  BOTTOM w0.127: v2(186.59,17.71) 186.16,18.14 JTP1.2
I2C1_SDA_TP: length 83.9
  TOP w0.127: QH7.6 188.58,15.83 RH461.1 187.88,15.83 v2(187.78,15.73)
  IN2 w0.089: v2(187.78,15.73) 184.16,15.73 180.95,18.95 v2(179.29,18.95)
  IN4 w0.081: v2(179.29,18.95) 178.31,19.92 177.2,19.92 175.62,21.5 175.62,24.77 173.54,26.86 173.54,27.99 170.26,31.27 170.26,36.24 167.82,38.68 167.82,40.34 167.49,40.68 167.49,42.88 167.82,43.22 167.82,43.72 168.44,44.33 168.44,44.73 167.97,45.2 167.46,45.2 166.23,46.44 165.71,46.44 159.4,52.75 159.4,56.45 160.54,57.59 160.54,59.02 v2(160.53,59.04) 160.55,59.04 160.93,59.42 160.93,62.19 160.15,62.98 158.98,62.98 157.81,61.8 156.72,61.8 156.35,62.17 152.96,62.17 152.87,62.26 152.39,62.26 151.36,61.24 148.35,61.24 v2(147.78,61.8)
  BOTTOM w0.127: RC284.2 159.82,59.67 160.45,59.04 v2(160.53,59.04) ; UCPU1.U8 148.09,63.08 147.78,62.77 147.78,61.81 v2(147.78,61.8)
I_ADP: length 207
  TOP w0.127: v2(189.69,65.25) 189.66,65.25 189.43,65.02 188.16,65.02 188.16,65.02 UE5.A12
  IN1 w0.081: v2(189.69,65.25) 189.48,65.25 189.31,65.08 184.45,65.08 183.88,64.51 180.57,64.51 179.42,63.35 179.05,63.35 178.83,63.57 178.55,63.57 177.22,62.25 174.71,62.25 174.44,61.98 174.44,60.99 174.32,60.86 174.32,58.3 175.07,57.55 175.07,55.57 174.5,54.99 174.5,54.62 172.14,52.26 172.14,48.33 169.22,45.41 169.22,44.6 166.68,42.07 166.68,40.89 166.12,40.32 165.81,40.32 165.45,39.96 165.45,37.92 164.29,36.76 164.29,34.09 164.47,33.9 164.47,28.25 155.99,19.77 126.03,19.77 125.46,19.2 118.38,19.2 117.57,20 112.67,20 110.63,22.05 103.1,22.05 102.86,21.8 97.93,21.8 96.25,23.48 96.25,26.51 92.09,30.67 91.68,30.67 90.09,32.26 87.98,32.26 87.63,32.61 84.07,32.61 81.77,30.32 76.8,30.32 73.05,26.56 64.13,26.56 61.3,23.73 59.84,23.73 59.31,23.2 56.07,23.2 55.24,24.02 50.99,24.02 50.45,23.49 50.45,22.59 48.26,20.4 44.39,20.4 43.82,20.98 43.82,22.09 43.01,22.89 41.11,22.89 38.4,25.6 38.4,26.23 v2(38.42,26.25)
  BOTTOM w0.127: v2(38.42,26.25) 37.95,25.78 37.95,24.47 38.15,24.27 PR315.1
I_BATT: length 188.3
  TOP w0.127: v2(44.57,18.34) 44.57,18.47 44.26,18.78 43.16,18.78 43.01,18.62 42.19,18.62 42.11,18.54 40.32,18.54 40.12,18.74 40.12,19.28 41.32,20.48 41.32,22.62 40.36,23.58 PR318.1
  IN1 w0.081: v2(44.57,18.34) 44.57,18.42 44.94,18.78 45.41,18.78 45.7,18.5 48.17,18.5 49.46,19.79 50.73,19.79 52.1,21.16 54.59,21.16 54.81,21.37 62.61,21.37 63.37,20.61 67.19,20.61 68.26,21.68 71.81,21.68 75.95,25.82 78.78,25.82 79.47,25.13 81.8,25.13 82.69,26.02 89.52,26.02 90.55,24.99 91.76,24.99 92.58,24.16 92.58,23.62 93.57,22.64 94.39,22.64 96.67,20.36 102.4,20.36 102.79,19.97 109.67,19.97 109.88,19.77 110.72,19.77 112.29,18.2 116.28,18.2 116.83,17.65 125.74,17.65 126.59,18.51 132.13,18.51 133.24,17.39 147.31,17.39 147.68,17.75 156.79,17.75 158.52,19.48 161.2,19.48 164.33,22.6 164.33,24.86 166.93,27.47 166.93,27.48 166.96,27.51 166.96,32.23 166.87,32.32 166.87,33.47 168.24,34.85 168.24,36.67 171.26,39.69 171.26,43.32 171.69,43.75 171.69,45.4 173.22,46.93 173.22,50.59 176.29,53.67 v2(177.15,53.67)
  BOTTOM w0.127: v2(177.15,53.67) 177.15,54.14 177.95,54.94 180.33,54.94 180.98,55.59 181.44,55.59 181.49,55.54 181.84,55.54 182.62,56.33 183.09,56.33 183.36,56.6 183.36,57.03 RE64.2
ILMT_1.0V: length 3.4
  TOP w0.127: PR708.2 PR709.1 202.62,62.32 201.93,63 v2(201.93,63.21)
  BOTTOM w0.127: PU700.3 201.91,63.23 v2(201.93,63.21)
ILMT_DDR: length 3.8
  TOP w0.203: PU600.17 171.54,31.7 171.98,32.14 171.98,32.83 172.49,33.33 PR606.1 PR604.2
IMON_IA: length 3.4
  TOP w0.203: PU1000.14 71.51,52.96 72.07,52.96 72.5,52.54 72.77,52.54 v2(72.8,52.51)
  BOTTOM w0.203: PC1065.2 72.16,52.56 72.75,52.56 v2(72.8,52.51)
  BOTTOM w0.254: PR1071.2 PC1065.2
IMON_VSA: length 3.3
  TOP w0.203: v2(70.43,57.29) 70.43,57.07 69.96,56.59 69.96,56.11 PU1000.23
  BOTTOM w0.203: PC1080.1 PR1069.1 70.46,57.26 v2(70.43,57.29)
IMVP_VR_ON: length 247.7
  TOP w0.127: UC11.2 53.45,42.89 53.57,43.01 54.59,43.01 54.99,42.6 RE100.2 55.2,41.08 v2(53.7,39.58) ; v2(188.77,59.7) 188.6,59.52 UE5.A1
  IN1 w0.089: v2(188.77,59.7) 186.61,61.86 186.07,61.86 185.83,61.63 182.63,61.63 181.85,60.85 181.85,58.9 181.37,58.42 179.97,58.42 178.29,56.74 178.29,55.43 178.64,55.08 178.64,53.99 175.76,51.11 175.76,49.23 173.94,47.42 173.94,46.75 172.33,45.13 172.33,43.48 171.92,43.08 171.92,39.45 170.19,37.72 170.19,35.19 172.53,32.85 172.53,21.08 171.65,20.2 162.84,20.2 161.48,18.84 158.81,18.84 157.02,17.05 152.44,17.05 151.07,15.68 134.05,15.68 131.87,17.87 126.86,17.87 125.37,16.37 117.2,16.37 116.02,17.56 112.03,17.56 111.57,18.01 103.05,18.01 101.36,19.7 96.4,19.7 94.1,22 92.49,22 89.14,25.35 82.92,25.35 82.07,24.5 79.2,24.5 78.66,25.04 76.08,25.04 71.43,20.39 69.35,20.39 66.99,18.03 65.04,18.03 62.41,20.66 55,20.66 53.24,18.91 49.48,18.91 48.31,17.74 47.14,17.74 47.12,17.72 43.71,17.72 43.32,18.11 43.32,19.63 42.3,20.65 42.3,21.5 41.63,22.17 40.94,22.17 40.04,23.07 39.06,23.07 38.58,23.55 38.58,24.23 37.57,25.24 37.57,31.45 39.17,33.05 40.05,33.05 42.13,35.13 42.13,35.56 45.83,39.26 v2(45.83,43.01)
  BOTTOM w0.127: v2(53.7,39.58) 53.23,39.11 52.36,39.11 52.05,39.42 52.05,41.36 51.53,41.87 50.67,41.87 50.22,42.32 46.41,42.32 45.83,42.9 v2(45.83,43.01)
IMVP_VR_ON_P: length 58.8
  TOP w0.127: v2(86.23,43.29) 86.59,43.65 PR1501.1 ; PR1029.1 63.6,49.81 v2(63.28,49.49) 63.73,49.04 63.73,47.2 61.51,44.98 59.98,44.98 58.78,46.19 58.01,46.19 v3(56.68,44.86) 56.36,44.54 56.36,43.72 RE101.1 RE100.1 54.27,43.52 54.1,43.69 54.1,44.14 UC11.4
  TOP w0.254: v2(82.75,34.52) 83.02,34.79 PR1512.1
  IN1 w0.081: v2(63.28,49.49) 66.02,49.49 71.55,43.95 84.03,43.95 84.6,44.51 85.26,44.51 86.23,43.54 v2(86.23,43.29)
  IN4 w0.081: v2(86.23,43.29) 86.39,43.44 87.35,43.44 87.96,42.83 87.96,37.42 87.04,36.5 87.04,36.38 86.75,36.09 85.17,36.09 83.61,34.52 v2(82.75,34.52)
INA199_OUT: length 53.4
  TOP w0.127: PU201.3 89.85,73.31 90.71,73.31 v2(90.73,73.29) 90.73,74.02 PC204.1 PR227.1 90.71,76.15 90.71,76.67 PD201.1 89.51,76.23 v3(89.51,75.62)
  BOTTOM w0.127: PR214.1 61.28,61.25 61.28,63.03 60.91,63.39 60.91,64.59 60.13,65.37 60.13,67.72 60.76,68.35 63.96,68.35 64.16,68.55 67.65,68.55 67.78,68.42 72.61,68.42 74.12,69.94 75.55,69.94 75.9,70.29 79.04,70.29 79.4,69.93 82.92,69.93 83.68,70.69 84.51,70.69 86.9,68.31 90.31,68.31 91.64,69.65 91.64,72.37 v2(90.73,73.29)
INTRUDER#: length 14
  TOP w0.127: RC69.1 147.93,45.95 v2(147.8,46.08) ; v2(142.6,54.37) 143.05,54.82 v1(143.05,55.33)
  IN4 w0.081: v2(147.8,46.08) 148.26,46.53 148.26,48.65 145.46,51.45 144.98,51.45 144.56,51.87 144.14,51.87 143.08,52.93 143.08,54.19 142.89,54.37 v2(142.6,54.37)
  BOTTOM w0.076: UCPU1.AP16 v2(142.6,54.37)
INV_PWM_R: length 7.1
  TOP w0.127: R545.1 MC3.1 193.55,28 v2(193.73,28) ; R545.1 192.53,29.9 191.24,29.9 190.66,30.48 D73.1 ; R545.1 193.54,29.95 v3(194.09,29.95)
  BOTTOM w0.127: JEDP.8 193.6,27.87 v2(193.73,28)
IRQ_SERIRQ: length 62.5
  TOP w0.127: v2(180.72,69.43) 180.72,69.43 180.86,69.29 180.86,68.72 UE5.A28
  IN1 w0.081: v2(152.78,41.94) 152.98,42.15 155.85,42.15 157.2,43.49 160.27,43.49 161.11,42.65 163.28,42.65 167.58,46.95 169.57,46.95 171.3,48.68 171.3,52.61 171.63,52.95 171.63,58.07 173.27,59.71 173.27,61.29 173.35,61.37 173.35,63.4 175.22,65.27 175.22,65.94 175.87,66.59 177.2,66.59 178.87,68.26 180.49,68.26 180.82,68.59 180.82,69.33 180.72,69.43 v2(180.72,69.43)
  BOTTOM w0.076: 147.08,46.22 146.46,46.85 146.46,48.8 145.72,49.54 145.72,50.62 UCPU1.AY11
  BOTTOM w0.127: 147.08,46.22 147.86,45.45 RC21.2 148.09,45.45 148.64,44.9 148.64,44.28 149.63,43.29 v3(150.57,43.29) 151.44,43.29 v2(152.78,41.94)
ISEN1_GT: length 11.3
  TOP w0.203: PR1127.1 70.56,49.11 PC1070.2 ; PC1070.2 70.71,49.13 70.94,49.36 70.94,50 70.36,50.58 PU1000.9 ; PC1070.2 70.59,49.62 v2(70.46,49.74)
  IN2 w0.254: v2(70.46,49.74) 71.6,49.74 73.44,47.9 73.44,46.39 v2(73,45.94)
  BOTTOM w0.254: PR1120.1 73.64,45.12 PR1118.2 73.04,45.98 v2(73,45.94)
ISEN2_GT: length 7.7
  TOP w0.127: v3(72.78,50.5) PR1128.1
  TOP w0.203: PR1128.1 73.76,50.48 v2(73.03,49.74) 72.92,49.64 71.98,49.64 PC1133.2 71.29,49.32 71.29,50.14 70.76,50.66 PU1000.10
  BOTTOM w0.254: PR1109.2 PR1112.2 73.23,49.95 v2(73.03,49.74)
ISUMN_GT: length 46.6
  TOP w0.203: PC1070.1 PC1133.1 PC1084.1
  TOP w0.254: v2(72.14,46.49) 72.14,47.46 72.37,47.68 PC1084.1 72.97,48.22 v2(75.21,45.98)
  IN2 w0.254: v2(72.14,46.49) 72.14,46.12 74.52,43.73 74.52,40.35 79.48,35.39 84.09,35.39 86.03,37.33 86.03,38.08 87.5,39.56 87.5,41.61 88.49,42.6 90.72,42.6 90.87,42.76 v2(91.03,42.76)
  BOTTOM w0.203: PC1094.2 PC1085.2 PC1133.1 ; PC1133.1 PC1084.1 ; PC1133.1 71.5,48.19 PR1062.2
  BOTTOM w0.254: PC1084.1 72.37,47.53 72.14,47.3 v2(72.14,46.49) ; PR1115.2 v2(75.21,45.98) 76.24,47.01 PR1107.2 ; v2(91.03,42.76) 91.03,43.37 PH1005.2
ISUMN_IA: length 31.1
  TOP w0.127: v2(75.79,58.25) 75.54,58.25 v3(74.76,59.03)
  TOP w0.203: PR1085.2 PR1068.2 75.82,58.23 v2(75.79,58.25)
  IN3 w0.203: v2(75.79,58.25) 75.92,58.38 76.43,58.38 76.94,57.87 77.63,57.87 78.55,58.78 79.88,58.78 80.62,59.52 80.62,60.66 81.08,61.12 85.37,61.12 85.7,60.79 89.64,60.79 90.63,61.78 90.63,62.67 v2(90.91,62.95)
  BOTTOM w0.203: PH1009.2 90.91,66.96 v2(90.91,62.95) PR1131.2 ; PR1078.2 PC1075.2 PC1067.2 75.49,56.9 PC1083.1 75.79,57.11 v2(75.79,58.25)
ISUMN_VSA: length 19.5
  TOP w0.203: PR1075.2 66.65,60 PR1092.2 v2(66.62,60.66)
  BOTTOM w0.127: 75.25,59.51 76.19,59.51 76.67,59.03 v3(76.67,58.79)
  BOTTOM w0.203: PR1058.2 PR1075.2 ; PR1075.2 PC1071.2 ; PR1075.2 PC1087.1 66.65,60.64 ; 66.65,60.64 v2(66.62,60.66) ; 66.65,60.64 66.75,60.54 69.38,60.54 70.2,59.72 72.37,59.72 72.57,59.93 73.84,59.93 PH1006.2 75.31,59.57 75.31,61.91 PR1137.2
ISUMP_GT: length 16.2
  TOP w0.203: PU1000.7 69.56,50.57 69.53,50.54 69.53,49.83 v2(69.62,49.74)
  IN2 w0.254: v2(72.82,47.24) 72.82,47.76 71.48,49.11 70.26,49.11 v2(69.62,49.74)
  IN4 w0.254: v2(72.82,47.24) 74.18,47.24 75.86,48.92 v2(75.86,49.81)
  BOTTOM w0.203: v2(69.62,49.74) 69.7,49.67 PC1094.1 PC1085.1 69.57,48.09 PR1088.1 69.7,46.82 PR1062.1
  BOTTOM w0.254: v2(72.82,47.24) 73.44,47.86 PR1116.1 ; v2(75.86,49.81) 75.86,50.31 PR1111.1
ISUMP_IA: length 6.1
  TOP w0.203: v2(72.47,55.23) 72.2,54.96 PU1000.19
  BOTTOM w0.203: PR1078.1 PC1075.1 PC1067.1 73.64,57.97 ; PR1078.1 73.64,54.36 PR1097.1 ; PR1078.1 72.57,55.13 v2(72.47,55.23)
ISUMP_VSA: length 7.3
  TOP w0.203: v2(68.15,57.19) 68.36,56.99 68.36,56.11 PU1000.27
  BOTTOM w0.203: PC1071.1 68.02,57.69 68.02,57.32 v2(68.15,57.19)
  BOTTOM w0.254: PC1071.1 PC1078.1 PR1058.1 PR1089.1 64.3,58.75 PR1091.2
ITP_PMODE: length 104.2
  TOP w0.127: JXDP1.46 67.6,67.33 67.6,68.48 v2(65.02,71.05)
  IN3 w0.089: v2(146.53,74.68) 146.31,74.91 144.41,74.91 144.07,75.24 143.46,75.24 143.31,75.09 142.93,75.09 142.81,75.21 140.26,75.21 139.66,74.61 139.66,73.2 139.76,73.1 139.76,72.46 138.56,71.26 135.21,71.26 134.77,71.69 129.33,71.69 128.83,71.18 127.81,71.18 127.31,71.69 121.65,71.69 121.05,71.09 117.83,71.09 117.46,71.46 113.91,71.46 113.04,70.59 112.13,70.59 110.52,68.97 106.79,68.97 106.22,68.41 100.66,68.41 99.29,69.77 93.74,69.77 91.7,67.73 83.86,67.73 82.26,69.34 79.08,69.34 78.11,70.31 74.16,70.31 73.39,71.08 71.37,71.08 70.89,71.56 65.53,71.56 v2(65.02,71.05)
  BOTTOM w0.076: 146.97,74.47 146.79,74.29 146.79,73.97 147.05,73.71 147.05,73.14 146.98,73.08 146.98,72.5 147.05,72.44 147.05,72.02 147.15,71.92 147.15,70.07 UCPU1.E8
  BOTTOM w0.127: RC115.1 146.97,75.39 146.97,74.47 ; RC115.1 146.53,75.57 v2(146.53,74.68) ; RC115.1 146.66,75.71 146.32,76.05 v3(145.53,76.05)
JACK_PLUG: length 14.4
  TOP w0.254: QA3.5 v2(15.72,30.95)
  IN2 w0.254: JHP1.6 9.63,35.57 9.96,35.9 13.26,35.9 v2(13.67,35.49)
  BOTTOM w0.254: v2(13.67,35.49) 15.04,34.12 15.04,33.44 16.28,32.19 DA1.3 15.65,32.06 15.33,31.75 15.21,31.75 RA35.1 14.83,30.36 RA26.1 14.88,30.45 15.38,30.95 v2(15.72,30.95)
JACK_PLUG_DL: length 12.5
  TOP w0.127: v3(18.69,34.45) 18.46,34.22 18.46,32.1 16.96,30.6 16.79,30.6 QA3.6
  TOP w0.254: v2(15.72,28.79) 15.91,28.98 CA74.1 ; QA3.6 16.37,29.69 16.42,29.64 CA74.1 ; CA74.1 16.62,28.77 RA31.1 18.06,28.77 18.38,29.09 QA6.2
  BOTTOM w0.254: RA20.1 16.66,29.42 RA38.2 ; RA20.1 RA26.2 ; RA20.1 15.8,28.86 v2(15.72,28.79)
JACK_PLUG_DL#: length 16.6
  TOP w0.203: v2(29.27,33.68) 29.31,33.71 RA75.1
  TOP w0.254: RA31.2 17.3,29.76 17.3,30.49 18.32,31.52 QA6.1 v2(19.03,32.7)
  IN4 w0.254: v2(19.03,32.7) 20.5,34.17 24.36,34.17 24.94,34.76 28.66,34.76 29.27,34.14 v2(29.27,33.68)
JTAG_CLK: length 28.4
  TOP w0.127: v2(180.72,59.29) 180.72,59.29 180.61,59.18 UE5.B56
  BOTTOM w0.127: JDEG1.4 171.15,67.9 170.92,67.68 170.92,65.97 171.15,65.74 RPE7.3 171.15,65 171.35,64.8 171.73,64.8 172.01,64.52 172.01,63.29 171.84,63.13 171.03,63.13 170.44,62.53 170.44,59.01 171.75,57.7 171.75,56.36 v3(172.84,55.26) 173.93,54.17 176.15,54.17 177.51,55.53 179.41,55.53 180.09,56.21 180.09,56.76 180.73,57.41 180.73,59.28 v2(180.72,59.29)
JTAG_RST#: length 17.7
  TOP w0.127: v2(179.5,60.84) 179,61.35 178.44,61.35 178.36,61.27 UE5.B47
  IN2 w0.089: v2(172.47,61.98) 172.47,61.61 175.85,58.23 176.42,58.23 178.19,60.01 178.19,61.01 178.49,61.3 179.04,61.3 v2(179.5,60.84)
  BOTTOM w0.127: v2(172.47,61.98) 173.77,61.98 174.22,61.53 CE59.1 RE66.1 RE65.2 171.4,61.38 JTAG1.1
JTAG_TDI: length 26.8
  TOP w0.127: v2(178.16,54.39) 178.54,54.39 178.77,54.62 178.77,56.68 179.33,57.24 179.65,57.24 179.86,57.46 UE5.A51
  BOTTOM w0.127: JDEG1.2 170.15,67.73 170.35,67.53 170.35,65.83 170.16,65.64 RPE7.1 170.16,65.25 169.58,64.67 169.58,62.72 v3(169.63,62.67) 169.63,62.21 169.72,62.13 169.72,57.18 173.65,53.25 177.35,53.25 177.69,53.59 177.69,53.91 v2(178.16,54.39)
JTAG_TDO: length 28.1
  TOP w0.127: UE5.B55 180.11,59.42 180.2,59.5 180.17,59.53 v2(180.17,59.53)
  BOTTOM w0.127: v2(180.17,59.53) 179.95,59.75 178.74,59.75 178.45,59.47 178.45,58.95 178.56,58.84 178.56,56.19 178.35,55.98 177.6,55.98 176.1,54.48 175.72,54.48 v3(175,55.2) 174.29,55.91 172.75,55.91 172.06,56.59 172.06,57.82 170.69,59.19 170.69,61.74 171.05,62.1 171.63,62.1 172.28,62.75 172.28,64.64 171.65,65.26 RPE7.4 171.65,65.77 171.19,66.23 171.19,67.48 171.65,67.93 171.65,68.22 JDEG1.5
JTAG_TMS: length 26.4
  TOP w0.127: v2(180.52,56.39) 180.39,56.52 180.39,57.07 180.86,57.54 UE5.A53
  BOTTOM w0.127: JDEG1.3 170.66,68.22 170.66,65.36 ; v2(180.52,56.39) 180.52,56.24 179.51,55.23 177.57,55.23 175.94,53.6 173.89,53.6 v3(171.07,56.43) 169.99,57.51 169.99,62.01 170.03,62.05 170.03,63.24 169.84,63.43 169.84,64.56 170.08,64.8 170.36,64.8 170.66,65.1 170.66,65.36 ; 170.66,65.36 RPE7.2
KB_DET#: length 185.1
  TOP w0.127: v3(154.52,45.9) 154.8,46.17 v2(154.8,47.59)
  IN4 w0.081: v2(154.8,47.59) 155.03,47.36 155.03,46.4 155.94,45.48 155.94,44.67 156.92,43.7 156.92,41.24 160.65,37.51 160.65,36.09 162.39,34.35 163.09,34.35 163.94,33.5 163.94,29.86 162.27,28.19 162.27,27.53 163.66,26.13 163.66,22.88 160.69,19.9 147.89,19.9 147.49,20.3 145.16,20.3 144.65,19.8 123.87,19.8 123.47,20.2 107.12,20.2 106.61,20.71 101.61,20.71 99.59,22.73 97.76,22.73 97.32,23.17 97.32,25.36 97.23,25.45 97.23,29.17 96.41,29.99 96.41,33.41 95.45,34.36 90.72,34.36 89.92,35.17 86.64,35.17 86.17,34.7 86.17,34.08 85.72,33.63 84.47,33.63 82.65,31.81 78.88,31.81 77.79,30.71 76.93,30.71 74.11,27.89 71.65,27.89 69.33,25.57 69.33,24.37 66.1,21.15 63.98,21.15 61.94,19.1 59.22,19.1 56.71,21.61 54.14,21.61 53.93,21.39 53.42,21.39 53.38,21.44 50.38,21.44 49.28,20.34 45.27,20.34 44.86,20.75 44.86,21.36 45.13,21.64 v2(45.13,21.89)
  BOTTOM w0.076: 153.46,47.83 153.3,48 150.82,48 150.23,48.59 149.97,48.59 149.15,49.41 148.68,49.41 UCPU1.BB7
  BOTTOM w0.127: JKB1.5 44.92,20.85 44.85,20.92 44.85,21.34 45.13,21.61 v2(45.13,21.89) ; RC288.2 155.31,47.08 v2(154.8,47.59) 154.6,47.39 153.9,47.39 153.46,47.83
LAN_WAKE#: length 77.3
  TOP w0.127: v2(182.47,67.17) 182.47,67.27 182.11,67.63 182.11,67.87 UE5.B27 ; RC95.2 147.39,48.47 147.02,48.47 146.77,48.71 146.77,49 146.2,49.57 146.2,51.33 145.44,52.09 145.15,52.09 144.93,52.3 144.93,54.48 144.7,54.71 144.12,54.71 143.99,54.83 143.99,55.33 143.68,55.64 v2(143.51,55.64)
  IN1 w0.081: v2(182.47,67.17) 182.47,67.19 181.95,67.71 181.95,69.72 181.84,69.83 181.84,70.52 181.48,70.87 179.39,70.87 178.65,70.13 178.25,70.13 177.68,69.56 177.68,69.46 176.53,68.31 176.15,68.31 175.95,68.51 174.73,68.51 173.38,67.16 173.38,65.32 172.01,63.95 172.01,62.7 171.73,62.42 171.71,62.42 171.65,62.37 171.65,61.62 169.13,59.1 169.13,56.91 170.08,55.96 170.08,53.71 166.8,50.42 166.8,49.52 163.85,46.57 158.96,46.57 158.53,46.15 154.43,46.15 153.78,46.8 153.78,47.3 152.98,48.09 152.57,48.09 152.27,48.39 150.25,48.39 147.74,50.9 146.85,50.9 145.69,52.05 145.21,52.05 144.96,52.31 144.96,54.36 144.6,54.72 144.11,54.72 143.97,54.86 143.97,55.13 143.51,55.58 v2(143.51,55.64)
  BOTTOM w0.076: UCPU1.AM15 v2(143.51,55.64)
LCD_TST: length 52
  TOP w0.127: v3(172.14,64.35) 172.44,64.35 172.95,63.84 RE58.2 173.64,64.28 174.45,64.28 174.78,64.6 175.35,64.6 175.57,64.38 v2(176.46,64.38) 176.46,64.39 176.59,64.52 UE5.A38
  IN4 w0.081: v2(176.46,64.38) 176.47,64.38 177.06,63.8 177.06,63.24 177.97,62.33 177.97,60.28 178.6,59.65 179.01,59.65 179.25,59.42 179.25,59.18 180.71,57.71 186.19,57.71 186.98,56.92 186.98,56.26 185.47,54.76 185.47,53 188.01,50.46 188.01,49.03 190.31,46.73 190.31,44.04 189.52,43.25 189.52,40.97 190.24,40.24 191.24,40.24 193.08,38.41 193.08,34.03 194.11,33 v2(194.19,33)
  BOTTOM w0.127: JEDP.19 193.81,33.37 v2(194.19,33)
LCD_VCC_TEST_EN: length 57.1
  TOP w0.127: D94.2 203.36,44.89 201.44,44.89 200.98,45.35 200.98,46.26 v1(198.22,49.03) v2(197.38,49.03) ; UE5.A39 176.82,64.02 176.66,63.86 v2(176.18,63.86)
  IN1 w0.081: v2(197.38,49.03) 197.55,49.2 197.55,49.97 194.47,53.05 194.47,62.73 195.8,64.06 195.8,68.25 194.32,69.73 191.52,69.73 191.13,70.12 184.49,70.12 183.74,69.38 183.74,66.39 183.3,65.94 182.76,65.94 182.63,66.07 181.75,66.07 181.02,66.81 179.1,66.81 177.17,64.87 177.17,64.52 176.5,63.86 v2(176.18,63.86)
LDO_EN: length 17.6
  TOP w0.508: v2(63.07,66.69) 63.07,67.5 60.6,69.97 PD205.1 59.52,69.9 PD204.1
  BOTTOM w0.127: v3(63.49,63.18) 64.06,63.75 PR240.2
  BOTTOM w0.381: v2(63.07,66.69) 63.17,66.79 63.71,66.79 64.18,67.26 64.18,67.76 64.59,68.17 66.32,68.17 PC209.1 66.51,67.45 PU202.1
  BOTTOM w0.508: v2(63.07,66.69) 63.07,66.54 64.06,65.55 PR240.2
LID_CL_SIO#: length 6.3
  TOP w0.127: RE26.2 RE25.2 184.4,73.21 184.66,72.96 184.66,72.42 184.43,72.2 184.43,71.41 CE13.1 184.89,70.11 v3(184.79,70.02) 184.36,69.59 184.36,68.72 UE5.A21
LID_SW_IN#: length 67.9
  TOP w0.127: v3(183.08,75.45) 182.57,74.94 v2(182.57,74.38) 182.83,74.13 RE26.1
  IN4 w0.089: v2(182.57,74.38) 182.32,74.13 182.32,72.35 184.19,70.48 184.19,69.09 184.73,68.54 184.73,66.73 185.55,65.92 185.55,65.39 185.74,65.2 186.73,65.2 188.19,63.74 188.19,61.21 189.64,59.76 189.64,59.38 191.28,57.73 191.28,56.95 193.6,54.63 193.6,51.84 195.87,49.57 195.87,36.14 198.65,33.36 198.65,25.76 199.31,25.1 v2(199.97,25.1)
  BOTTOM w0.127: JIO1.44 197.31,18.73 198.02,19.44 198.67,19.44 198.8,19.57 198.8,20.59 199.44,21.23 199.44,24.57 v2(199.97,25.1)
LINE1-VREFO_L: length 7.4
  TOP w0.127: UA2.31 24.61,29.48
  TOP w0.203: 24.61,29.48 24.06,29.48 24.04,29.49 24.01,29.49
  TOP w0.254: 24.01,29.49 23.44,29.49 23.31,29.62 21.74,29.62 21.13,29.02 v2(20.79,29.02)
  BOTTOM w0.127: v3(21.32,28.57) 20.88,29.02 v2(20.79,29.02)
  BOTTOM w0.254: v2(20.79,29.02) 20.55,28.77 RA48.1
LINE1-VREFO_R: length 9.4
  TOP w0.203: UA2.30 23.91,29.88
  TOP w0.254: v2(21,29.57) 21.56,30.13 v3(22.71,30.13) 23.34,30.13 23.6,29.88 23.91,29.88
  IN1 w0.254: v2(21,29.57) 21,29.74 20.78,29.96 18.9,29.96 18.54,30.31 v2(17.81,30.31)
  BOTTOM w0.254: v2(17.81,30.31) 17.56,30.07 RA49.1
LINE1_L: length 12.9
  TOP w0.203: v2(25.63,33.54) 25.86,33.54 26.26,33.13 UA2.22
  TOP w0.381: v2(19.1,28.85) 19.6,28.36 CA70.1
  IN4 w0.254: v2(19.1,28.85) 19.77,29.51 19.77,31.48 20.63,32.34 22.76,32.34 23.47,33.05 25.25,33.05 25.63,33.43 v2(25.63,33.54)
  BOTTOM w0.127: v3(24.81,34.49) 25.63,33.67 v2(25.63,33.54)
LINE1_L_C: length 7.7
  TOP w0.127: CA70.2 19.65,27.44 18.78,28.31 13.96,28.31 13.58,28.7 v3(13.58,28.97)
  TOP w0.254: RA50.1 CA70.2
LINE1_R: length 12.5
  TOP w0.203: UA2.21 26.66,33.19 26.31,33.54 v2(26.31,33.74)
  IN4 w0.254: v2(18.45,30.95) 21.15,33.64 24.36,33.64 24.84,34.12 25.93,34.12 v2(26.31,33.74)
  BOTTOM w0.127: v2(26.31,33.74) 26.31,34.89 v3(26.46,35.03)
  BOTTOM w0.254: CA71.1 v2(18.45,30.95)
LINE1_R_C: length 2
  BOTTOM w0.127: v3(19.45,29.76) 19.1,29.41 CA71.2
  BOTTOM w0.254: RA51.1 CA71.2
LPC_AD0: length 52.6
  TOP w0.127: v2(179.91,69.45) 179.86,69.41 179.86,68.72 UE5.A30
  IN3 w0.089: v2(144.74,48.89) 146.52,50.67 150.27,50.67 152.49,52.9 154.72,52.9 157.72,55.9 158.82,55.9 161.14,58.22 161.14,59.27 161.9,60.02 162.99,60.02 163.38,60.41 165.51,60.41 168.08,62.99 169.24,62.99 171,64.75 172.34,64.75 172.8,65.22 172.8,66.06 176.95,70.21 179.15,70.21 v2(179.91,69.45)
  BOTTOM w0.076: v2(144.74,48.89) 144.53,49.1 144.53,49.79 144.59,49.91 144.59,50.05 144.52,50.28 144.52,50.4 144.59,50.61 144.69,50.72 144.8,50.83 UCPU1.AY13
  BOTTOM w0.127: v3(181.42,68.1) 181.26,68.1 v2(179.91,69.45) 179.91,69.94 180.65,70.68 180.65,71.22 JLPDE1.3
LPC_AD1: length 55.8
  TOP w0.127: UE5.B32 179.61,67.28 179.55,67.22 v2(179.55,67.2)
  IN3 w0.089: v2(145.9,46.96) 146.19,46.96 146.66,47.43 146.66,47.71 148.33,49.38 150.61,49.38 152.36,51.12 157.36,51.12 159.36,53.12 159.36,54.91 161.71,57.26 165.58,57.26 166.42,58.1 166.42,59.14 167.21,59.93 169.52,59.93 174.24,64.65 174.88,64.65 175.46,65.24 175.46,65.82 176.01,66.37 177.71,66.37 178.13,66.79 179.12,66.79 179.54,67.2 v2(179.55,67.2)
  BOTTOM w0.076: UCPU1.BA13 145.09,50.04 145.09,49.43 145.38,49.13 145.38,47.48 v2(145.9,46.96)
  BOTTOM w0.127: v2(179.55,67.2) 179.55,67.22 179.5,67.27 v3(179.5,68.33) 179.45,68.39 179.45,70.05 179.25,70.25 179.25,71.6 179.57,71.92 180.88,71.92 181.15,71.65 JLPDE1.4
LPC_AD2: length 52.9
  TOP w0.127: UE5.A31 179.36,68.72 179.36,69.26 179.01,69.61 v2(179.01,69.64)
  IN3 w0.089: v2(179.01,69.64) 178.65,70 177.04,70 173.02,65.98 173.02,64.99 172.56,64.54 171.09,64.54 169.33,62.77 168.17,62.77 165.6,60.2 163.47,60.2 163.08,59.81 161.99,59.81 161.36,59.18 161.36,58.13 158.91,55.68 157.81,55.68 154.81,52.68 152.58,52.68 150.36,50.45 146.94,50.45 144.99,48.5 v2(144.99,48.24)
  BOTTOM w0.076: v2(144.99,48.24) 145.14,48.39 145.14,49.13 144.87,49.4 144.87,49.61 UCPU1.BB13
  BOTTOM w0.127: JLPDE1.5 181.65,71.22 181.65,71.64 181.02,72.27 179.56,72.27 178.97,71.68 178.97,69.68 v2(179.01,69.64)
LPC_AD3: length 60.2
  TOP w0.127: v2(178.72,67.19) 178.72,67.22 179.11,67.61 UE5.B33
  IN3 w0.089: v2(146.08,47.54) 146.79,48.25 146.79,49.23 147.31,49.76 150.64,49.76 152.32,51.44 153.11,51.44 153.71,52.03 155.08,52.03 155.33,51.78 157.72,51.78 159.14,53.21 159.14,55 162.01,57.86 162.01,58.04 162.25,58.28 162.88,58.28 163.68,57.48 165.49,57.48 166.2,58.19 166.2,59.23 167.12,60.14 169.43,60.14 174.15,64.87 174.79,64.87 175.25,65.33 175.25,65.73 175.25,65.91 175.92,66.58 177.56,66.58 177.98,67 178.5,67 178.69,67.19 v2(178.72,67.19)
  BOTTOM w0.076: v2(146.08,47.54) 145.7,47.54 145.55,47.7 145.55,49.2 145.29,49.46 145.29,50.16 145.09,50.37 145.09,50.91 145.37,51.19 UCPU1.AY12
  BOTTOM w0.127: v2(178.72,67.19) 178.72,68.32 178,69.04 178,71.07 179.91,72.98 181.53,72.98 182.15,72.37 182.15,71.22 JLPDE1.6
LPC_FRAME#: length 55.4
  TOP w0.127: UE5.B31 180.11,67.24 180.14,67.22 v2(180.14,67.2)
  IN3 w0.089: v2(145.9,48.13) 146.58,48.81 146.58,49.34 147.27,50.02 150.59,50.02 152.23,51.65 153.02,51.65 153.62,52.25 154.99,52.25 156.21,53.47 157.95,53.47 158.9,54.42 158.9,55.06 161.79,57.95 161.79,58.13 162.16,58.49 162.97,58.49 163.77,57.69 165.4,57.69 165.98,58.27 165.98,59.32 167.03,60.36 169.01,60.36 170.51,61.86 170.51,63.1 171.51,64.11 172.74,64.11 173.45,64.81 173.45,65.68 174.08,66.31 175.14,66.31 176.43,67.6 179.74,67.6 v2(180.14,67.2)
  BOTTOM w0.076: UCPU1.BA12 145.4,50.66 145.56,50.5 145.56,49.47 145.9,49.12 v2(145.9,48.13)
  BOTTOM w0.127: v2(180.14,67.2) 180.14,67.47 180.35,67.69 181.68,67.69 181.97,67.98 181.97,69.03 181.81,69.19 181.81,70.24 182.14,70.57 182.5,70.57 182.65,70.72 JLPDE1.7
LPM_ZVM_N: length 67
  TOP w0.127: v2(94.11,35.98) 95.48,35.98 96.47,36.97 v1(96.47,40.86) 96.47,43.47 96.16,43.77 93.24,43.77 92.81,43.34 90.88,43.34 90.4,42.86 PR1500.1
  TOP w0.254: PR1511.1 86.17,33.65 v2(86.72,33.65)
  IN2 w0.089: v2(119.74,53.74) 119.48,53.48 119.48,52.86 119.13,52.51 119.13,51.45 114.86,47.18 114.63,47.18 114.28,46.82 114.28,43.06 111.21,40 104.76,40 103.78,39.02 103.78,36.84 102.32,35.38 102.17,35.38 100.18,33.38 98.65,33.38 98.21,33.82 95.87,33.82 v2(95.25,33.21)
  BOTTOM w0.076: v2(119.74,53.74) 120.1,54.1 UCPU1.AR56
  BOTTOM w0.127: v2(95.25,33.21) 94.37,34.09 94.37,35.72 v2(94.11,35.98) 90.7,35.98 90.2,35.47 90.2,34.68 89.36,33.85 88.73,33.85 88.62,33.74 86.81,33.74 v2(86.72,33.65)
LX_1.0V: length 1.6
  TOP w0.508: PC703.2 200.06,60.09 v2(200.76,60.79)
LX_1V_PRIM:
  vias: v2(89.39,29.19)
LX_3V:
  vias: v2(84.71,22.44) v2(85.32,22.44) v3(83.03,20.15)
LX_5V:
  vias: v2(57.7,43.96) v2(57.7,42.31) v3(57.48,43.09)
LX_DDR:
  vias: v2(169.35,28.22)
LX_PRIM: length 1.1
  TOP w0.127: 197.62,73.01 197.62,72.24 v1(197.85,72.01)
LX_VCC_EDRAM:
  vias: v2(92.44,39.21)
LX_VCCIO:
  vias: v3(171.87,49.53)
MCARD_PCIE_SATA#: length 77.1
  IN4 w0.081: v2(180.65,66.2) 180.65,65.87 183.23,63.29 183.23,59.21 183.66,58.78 186.65,58.78 187.94,57.49 188.62,57.49 188.86,57.25 188.86,56.58 188.6,56.31 188.22,56.31 186.32,54.41 186.32,53.53 188.97,50.88 191.14,50.88 192.98,49.04 192.98,48.58 v2(192.99,48.57)
  BOTTOM w0.127: 186.92,39.98 185.94,39.98 R220.2 185.54,39.57 184.48,39.57 183.76,40.29 JNGFF2.61 ; 186.92,39.98 187.44,39.98 187.97,40.51 187.97,40.73 188.57,41.34 188.57,43.31 189.02,43.76 190.15,43.76 192.22,45.82 192.22,47.8 v2(192.99,48.57) ; 186.92,39.98 U683.2 ; R2665.2 156.81,71.7 159.4,71.7 160.67,70.43 164.11,70.43 164.49,70.82 165.51,70.82 v3(165.71,70.62) 166.43,70.62 167.72,69.33 168.13,69.33 169.59,70.79 173.35,70.79 174.74,69.4 174.74,68.27 174.63,68.16 174.63,67.25 174.95,66.93 175.55,66.93 176.02,67.4 177.15,67.4 178.22,66.33 178.22,65.39 178.51,65.11 179.75,65.11 179.79,65.06 180.65,65.06 181.03,65.44 181.03,65.81 v2(180.65,66.2)
ME_EN: length 14.6
  TOP w0.254: v2(160.17,48.7) 160.12,48.7 159.42,49.4 159.42,49.55 RH24.1 R1191.1
  BOTTOM w0.127: SW1.2 164.39,48.95 165.16,49.71 166.2,49.71 166.78,49.13 168.62,49.13 v3(169.76,47.99)
  BOTTOM w0.254: v2(160.17,48.7) 160.9,47.96 163.69,47.96 SW1.2
ME_FWP_EC: length 43.5
  TOP w0.127: v2(188.21,59.01) 187.83,59.01 187.57,59.27 187.21,59.27 UE5.B1 ; v2(159.99,49.52) 159.18,50.33 159.18,50.66 159.14,50.7 159.14,51.48 158.97,51.65 158.45,51.65 157.94,51.14 R1191.2
  IN2 w0.089: v2(188.21,59.01) 188.06,58.86 184.91,58.86 184.05,59.72 183.56,59.72 182.79,60.49 182.03,60.49 181.61,60.91 180.87,60.91 180.34,60.38 v2(180.19,60.38)
  IN3 w0.089: v2(180.19,60.38) 180.19,60.19 179.75,59.76 178.72,59.76 178.44,59.47 178.44,57.05 177.82,56.42 176.87,56.42 174.75,54.31 171.99,54.31 171.79,54.1 168.98,54.1 164.52,49.65 161.07,49.65 160.95,49.53 159.99,49.53 v2(159.99,49.52)
  BOTTOM w0.127: v2(159.99,49.52) v3(161.24,49.52) 161.83,49.52 SW1.3
ME_RESET#: length 2.7
  TOP w0.127: RC227.1 158.19,71.1 RC225.2 158.05,72.09 157.55,71.6 156.69,71.6 UC12.2
ME_SUS_PWR_ACK: length 78.6
  TOP w0.127: v2(189.63,62.65) 189.27,62.65 v3(189.09,62.83) 188.9,63.02 UE5.A8 ; v2(144.43,54.3) 144.1,54.3 143.93,54.13 143.93,53.02 143.57,52.66 143.57,49.4 142.88,48.7 RC74.2
  IN3 w0.089: v2(189.63,62.65) 190.49,63.52 190.49,65.88 189.71,66.66 189.71,67.8 190.38,68.48 190.38,69.06 188.24,71.2 184.4,71.2 183.92,71.69 179.02,71.69 178.62,71.29 174.73,71.29 173.26,69.83 173.26,69.26 171.84,67.84 171.21,67.84 170.74,67.37 163.97,67.37 162.84,66.25 161.69,66.25 160.93,65.49 160.93,61.68 160.61,61.36 160.08,61.36 159.47,60.76 159.47,60.5 157.51,58.53 157.05,58.53 156.18,57.66 154.76,57.66 154.22,58.2 151.16,58.2 149.91,56.96 144.81,56.96 144.6,56.75 144.6,56.63 143.96,55.99 143.96,54.76 v2(144.43,54.3)
  BOTTOM w0.076: UCPU1.AR13 144.88,54.12 144.71,54.3 v2(144.43,54.3)
MEC_XTAL1: length 8.8
  TOP w0.127: YE1.1 183.69,51.9 CE62.1 183.24,52.39 183.96,53.12 185.03,53.12 185.67,53.75 185.67,55.97 184.95,56.68 v3(184.95,56.77) 184.95,57.38 184.86,57.47 UE5.A61
MEC_XTAL2: length 4.4
  TOP w0.127: YE1.2 186.88,51.9 186.88,52.83 CE53.1 RE62.2 186.69,54.87 v1(187.08,55.27)
MEC_XTAL2_R: length 6.5
  TOP w0.127: UE5.A62 185.36,56.72 186.16,55.92 RE62.1 186.45,55.79 186.62,55.96 189.49,55.96 v3(189.98,55.47)
MEDIACARD_IRQ#: length 94.8
  IN4 w0.081: v2(154.09,67.88) 154.5,67.47 155.81,67.47 156.21,67.08 159.07,67.08 163.07,63.07 163.07,62.81 164,61.89 164.67,61.89 165.58,60.97 165.58,57.13 166.92,55.79 166.92,54.18 167.8,53.3 167.8,51.28 166.84,50.32 166.84,49.23 171.86,44.21 171.86,40.91 173.36,39.41 173.36,38.74 174.94,37.16 174.94,30.4 179.7,25.64 179.7,24.42 182.45,21.68 183.95,21.68 184.25,21.37 184.25,20.27 184.57,19.95 190.68,19.95 192.4,21.66 198.56,21.66 199.47,20.76 199.47,20.44 v2(199.41,20.39)
  BOTTOM w0.127: v2(199.41,20.39) 199.2,20.18 199.2,19.4 198.88,19.08 198.27,19.08 197.91,18.73 197.91,18.41 JIO1.42 ; RC13.2 157.48,70.77 156.7,69.99 155.07,69.99 154.09,69.01 v2(154.09,67.88) 154.43,67.53 154.43,66.68 153.35,65.59 152.53,65.59 152.12,66 UCPU1.M1
