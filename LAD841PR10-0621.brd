# Allegro board LAD841PR10-0621.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
R1212  0_0402_1%  [R0402_0OHM]  42.14 45.93 90 top
R1216  1M_0402_5%~D  [R_0402]  23.67 52.79 180 top
R1255  0_0402_5%  [R_0402]  43.54 45.93 90 top
R1299  100K_0402_5%~D  [R_0402]  184 22.18 180 top
R1318  0_0603_5%~D  [R0603_0OHM]  34.27 39.46 270 top
R1320  0_0603_5%~D  [R0603_0OHM]  48.55 21.57 180 top
R1322  0_0805_5%  [R0805_0OHM]  200.75 38.31 180 top
R1323  0_0603_5%~D  [R0603_0OHM]  168.89 18.5 270 top
R1325  0_0603_5%~D  [R0603_0OHM]  162.09 66.38 180 top
R1326  0_0805_5%  [R0805_0OHM]  177.61 29.42 180 top
R1327  0_0603_5%~D  [R0603_0OHM]  153.26 75.14 180 top
R1329  0_0805_5%  [R0805_0OHM]  39.6 43.81 90 top
R1333  0_0603_5%~D  [R0603_0OHM]  160.88 47.58 180 top
R1334  0_0603_5%~D  [R0603_0OHM]  111.65 71.89 0 top
R1335  0_0603_5%~D  [R0603_0OHM]  152.95 78.95 180 top
R1342  0_0805_5%  [R0805_0OHM]  181.33 29.76 270 top
R1343  0_0603_5%~D  [R0603_0OHM]  173.77 19.01 0 top
R1344  0_0805_5%  [R0805_0OHM]  35.66 45.08 90 top
R1376  10K_0402_5%~D  [R_0402]  175.36 31.76 90 top
R1377  10K_0402_5%~D  [R_0402]  175.29 36.51 0 top
R1393  0_0805_5%  [R0805_0OHM]  179.81 44.66 0 top
R1403  1M_0201_1%  [R_0201]  48.74 53.46 270 top
R1405  1M_0201_1%  [R_0201]  41.15 53.46 270 top
R1436  0_0402_1%  [R0402_0OHM]  27.2 66.13 0 top
R1437  0_0402_1%  [R0402_0OHM]  27.79 58.76 0 top
R1438  0_0402_1%  [R0402_0OHM]  17.88 61 0 top
R1439  0_0402_1%  [R0402_0OHM]  28.46 60.13 0 top
R1440  0_0402_1%  [R0402_0OHM]  31.67 61.93 180 top
R1441  0_0402_1%  [R0402_0OHM]  17.81 65.62 0 top
R1442  0_0402_1%  [R0402_0OHM]  17.81 66.51 0 top
R1443  0_0402_5%  [R_0402]  182.86 36.04 270 top
R1444  0_0402_1%  [R0402_0OHM]  181.97 36.04 270 top
R1445  0_0402_1%  [R0402_0OHM]  180.06 36.04 270 top
R1446  0_0402_5%  [R_0402]  179.17 36.04 270 top
R1454  10K_0402_5%  [R_0402]  29.19 63.46 180 top
R1457  0_0201_5%  [R_0201]  18.64 58.63 180 top
R1458  0_0201_5%  [R_0201]  18.3 59.22 180 top
R1459  0_0201_5%  [R_0201]  16.57 61.05 0 top
R1460  10K_0402_5%  [R_0402]  29.19 62.57 180 top
R1461  0_0201_5%  [R_0201]  20.98 62.39 90 bottom
R1462  100K_0402_5%  [R_0402]  30.38 57.49 0 top
R1463  0_0201_5%  [R_0201]  16.45 63.97 0 top
R1464  0_0201_5%  [R_0201]  17.03 63.33 180 top
R1465  0_0201_5%  [R_0201]  22.62 55.27 180 top
R1468  100K_0402_5%  [R_0402]  23.65 57.74 270 top
R1471  0_0201_5%  [R_0201]  24.98 67.98 180 top
R1472  100K_0402_5%  [R_0402]  21.18 67.28 270 top
R1473  15K_0402_1%  [R_0402]  23.15 62.77 270 bottom
R1474  3.3K_0402_1%  [R_0402]  23.47 38.11 90 top
R1475  3.3K_0402_1%  [R_0402]  29.24 64.32 180 top
R1476  3.3K_0402_1%  [R_0402]  22.2 47.75 0 top
R1477  3.3K_0402_1%  [R_0402]  20.93 38.11 90 top
R1478  100K_0402_5%  [R_0402]  17.81 64.73 0 top
R2662  0_0402_5%~D  [R_0402]  174.35 41.09 90 top
R2663  0_0402_1%  [R0402_0OHM]  186.67 32.98 180 bottom
R2664  0_0402_1%  [R0402_0OHM]  186.67 33.87 180 bottom
R2665  0_0402_1%  [R0402_0OHM]  155.68 71.92 0 bottom
R2669  0_0805_5%  [R0805_0OHM]  48.36 18.25 180 top
R2670  0_0603_5%~D  [R0603_0OHM]  55.6 75.42 90 top
R2671  0_0603_5%~D  [R0603_0OHM]  55.73 78.25 90 top
R2672  0_0805_5%  [R0805_0OHM]  181.41 47.38 180 top
RA15  10_0402_5%  [R_0402]  15.8 27.59 180 bottom
RA16  100K_0402_5%~D  [R_0402]  17.37 23.76 90 top
RA17  10_0402_5%  [R_0402]  19.71 24.72 0 bottom
RA18  10K_0402_5%~D  [R_0402]  19.15 19.82 90 top
RA19  10K_0402_5%~D  [R_0402]  19.66 33.94 270 bottom
RA20  100K_0402_5%~D  [R_0402]  15.8 29.42 180 bottom
RA24  1K_0402_1%  [R_0402]  25.4 38.08 270 top
RA25  1K_0402_1%  [R_0402]  26.29 38.08 270 top
RA26  0_0402_1%  [R0402_0OHM]  14.88 30.31 0 bottom
RA27  2.2K_0402_5%~D  [R_0402]  8.74 23.15 270 bottom
RA28  2.2K_0402_5%~D  [R_0402]  8.31 23.33 180 top
RA30  0_0402_1%  [R0402_0OHM]  19.66 32.17 270 bottom
RA31  0_0402_1%  [R0402_0OHM]  17.37 28.77 90 top
RA35  100K_0402_5%~D  [R_0402]  14.83 31.38 90 bottom
RA37  100K_0402_5%~D  [R_0402]  14.9 34.83 270 top
RA38  100K_0402_5%~D  [R_0402]  16.68 30.32 270 bottom
RA39  100K_0402_5%~D  [R_0402]  14.88 33.04 0 top
RA41  100K_0402_5%~D  [R_0402]  18.26 20.74 270 top
RA48  4.7K_0402_5%~D  [R_0402]  20.55 26.58 270 bottom
RA49  4.7K_0402_5%~D  [R_0402]  17.56 28.55 270 bottom
RA50  1K_0402_1%  [R_0402]  19.66 26.58 270 top
RA51  1K_0402_1%  [R_0402]  18.45 28.55 270 bottom
RA54  0_0402_1%  [R0402_0OHM]  25.55 34.38 0 top
RA57  1K_0402_5%~D  [R_0402]  20.04 19.82 90 top
RA58  22_0402_5%  [R_0402]  33.96 28.28 180 top
RA59  0_0402_1%  [R0402_0OHM]  31.22 24.09 90 top
RA60  9.09K_0402_1%  [R_0402]  16.68 27.63 90 bottom
RA61  9.09K_0402_1%  [R_0402]  19.66 25.66 90 bottom
RA62  33_0402_5%~D  [R_0402]  33.96 31.2 180 top
RA63  0_0402_1%  [R0402_0OHM]  24.36 26.96 270 bottom
RA64  0_0402_1%  [R0402_0OHM]  7.98 22.39 270 top
RA65  0_0402_1%  [R0402_0OHM]  7.85 22.23 90 bottom
RA75  200K_0402_1%  [R_0402]  29.31 34.3 90 top
RA76  100K_0402_1%~D  [R_0402]  31.17 34.38 180 top
RA77  100K_0402_1%~D  [R_0402]  22.15 32.09 180 top
RA80  0_0603_5%  [R0603_0OHM]  32.8 36.15 0 bottom
RA81  0_0603_5%~D  [R_0603]  34.65 22.63 90 top
RA82  0_0603_5%~D  [R_0603]  34.2 34.88 180 bottom
RC1  100K_0402_5%  [R_0402]  146.28 66.63 0 top
RC2  24.9_0402_1%  [R_0402]  122.28 68.41 90 top
RC3  100_0402_1%  [R_0402]  143.54 69.52 90 top
RC4  200_0402_1%  [R_0402]  155.6 54.31 0 bottom
RC5  200_0402_1%  [R_0402]  139.55 50.63 270 top
RC6  80.6_0402_1%  [R_0402]  140.44 50.63 270 top
RC7  162_0402_1%  [R_0402]  141.33 50.63 270 top
RC9  1K_0402_5%  [R_0402]  157.71 49.36 0 top
RC10  1K_0402_1%  [R_0402]  156.39 52.54 180 bottom
RC11  1K_0402_1%  [R_0402]  156.52 51.65 180 bottom
RC12  1K_0402_5%  [R_0402]  156.59 64.86 180 top
RC13  10K_0402_5%  [R_0402]  159.13 70.77 180 bottom
RC14  1K_0402_5%  [R_0402]  155.68 63.84 0 top
RC15  1K_0402_5%  [R_0402]  155.68 62.82 0 bottom
RC16  10K_0402_5%  [R_0402]  147.04 44.54 90 bottom
RC17  1K_0402_5%  [R_0402]  155.68 63.71 0 bottom
RC18  22_0402_5%  [R_0402]  155.68 45.3 0 bottom
RC19  0_0402_1%  [R0402_0OHM]  155.65 57.08 0 bottom
RC20  1K_0402_5%  [R_0402]  150.98 57.93 0 top
RC21  10K_0402_1%  [R_0402]  148.06 44.54 90 bottom
RC22  22_0402_5%  [R_0402]  155.68 46.19 0 bottom
RC23  8.2K_0402_5%  [R_0402]  155.68 65.74 0 top
RC25  10K_0402_5%  [R_0402]  155.68 61.93 0 bottom
RC26  4.7K_0402_5%  [R_0402]  149.76 55.58 0 top
RC27  8.2K_0402_5%  [R_0402]  151.18 44.79 180 bottom
RC29  33_0402_5%  [R_0402]  184.71 56.35 180 bottom
RC44  113_0402_1%  [R_0402]  150.68 60.74 0 top
RC45  100_0402_1%  [R_0402]  149.58 69.29 90 top
RC46  1M_0402_1%  [R_0402]  132.89 73.82 180 top
RC47  10K_0402_5%  [R_0402]  45.31 35.95 90 bottom
RC48  1K_0402_5%  [R_0402]  146.03 45.42 270 bottom
RC49  10K_0402_5%  [R_0402]  147.8 49.87 90 top
RC50  10K_0402_5%  [R_0402]  149.58 49.92 90 top
RC51  0_0201_5%  [R_0201]  150.72 67.77 270 top
RC52  2.7K_0402_1%  [R_0402]  128.25 70.11 270 top
RC53  0_0402_5%  [R_0402]  199.47 75.73 0 bottom
RC54  10M_0402_5%  [R_0402]  149.84 47.71 0 top
RC55  0_0402_5%  [R_0402]  200.38 69.48 90 bottom
RC56  20K_0402_5%  [R_0402]  147.04 45.42 270 top
RC57  20K_0402_5%  [R_0402]  148.82 45.42 270 top
RC58  0_0402_5%  [R_0402]  196.22 75.73 270 bottom
RC59  10K_0402_5%  [R_0402]  176.2 37.4 180 top
RC60  0_0402_5%  [R_0402]  197.46 75.73 270 bottom
RC61  0_0402_5%  [R_0402]  195.2 75.73 270 bottom
RC62  0_0402_5%  [R_0402]  194.18 75.6 270 bottom
RC63  10K_0402_5%  [R_0402]  61.84 50.95 180 bottom
RC64  0_0402_5%  [R_0402]  193.29 75.73 270 bottom
RC65  100K_0402_5%  [R_0402]  161.01 62.87 90 top
RC66  0_0402_5%  [R_0402]  192.28 74.81 90 bottom
RC67  1K_0402_5%  [R_0402]  144.63 45.55 0 top
RC69  330K_0402_5%  [R_0402]  147.93 45.42 270 top
RC71  1K_0402_5%  [R_0402]  113.51 78.06 180 bottom
RC72  8.2K_0402_5%  [R_0402]  147.93 48.09 0 top
RC73  10K_0402_5%  [R_0402]  152.18 44.81 0 bottom
RC74  10K_0402_5%  [R_0402]  141.96 45.3 0 top
RC75  10K_0402_5%  [R_0402]  143.99 42 90 top
RC77  1K_0402_5%  [R_0402]  110.03 73.19 0 top
RC78  60.4_0402_1%  [R_0402]  110.97 77 270 bottom
RC79  49.9_0402_1%  [R_0402]  117.45 77.05 180 bottom
RC80  1K_0402_5%  [R_0402]  115.29 77.12 270 top
RC81  51_0402_5%  [R_0402]  118.09 78.06 270 top
RC82  51_0402_5%  [R_0402]  120.88 77.68 90 top
RC83  1K_0402_5%  [R_0402]  111.42 77.06 270 top
RC84  499_0402_1%  [R_0402]  112.31 76.15 90 top
RC85  10K_0402_5%  [R_0402]  162.48 58.63 180 top
RC86  51_0402_5%  [R_0402]  119.86 78.57 270 top
RC87  1K_0402_5%  [R_0402]  118.47 76.92 90 bottom
RC88  49.9_0402_1%  [R_0402]  143.1 50.63 270 top
RC89  49.9_0402_1%  [R_0402]  142.22 50.63 270 top
RC90  49.9_0402_1%  [R_0402]  113.08 67.78 180 top
RC91  49.9_0402_1%  [R_0402]  115.24 67.01 180 top
RC92  33_0402_5%  [R_0402]  142.72 44.54 90 bottom
RC93  33_0402_5%  [R_0402]  140.82 44.54 90 bottom
RC94  33_0402_5%  [R_0402]  139.07 47.08 0 top
RC95  10K_0402_5%  [R_0402]  148.82 48.98 180 top
RC96  200_0402_1%  [R_0402]  147.47 62.44 180 top
RC97  43K_0603_1%  [R_0603]  177.9 55.06 90 top
RC109  10K_0402_1%  [R_0402]  107.34 71.46 0 top
RC110  10K_0402_1%  [R_0402]  109.64 76.93 270 top
RC112  10K_0402_1%  [R_0402]  108.75 76.93 270 top
RC113  10K_0402_1%  [R_0402]  110.53 77.06 270 top
RC114  49.9_0402_1%  [R_0402]  117.9 69.51 270 top
RC115  1.5K_0402_5%  [R_0402]  146.66 75.7 90 bottom
RC120  100K_0402_5%  [R_0402]  112.75 76.21 90 bottom
RC121  1K_0402_5%  [R_0402]  75.03 76.79 270 top
RC122  0_0402_5%  [R_0402]  78.33 75.95 90 top
RC123  1K_0402_5%  [R_0402]  70.71 75.88 90 top
RC124  1K_0402_5%  [R_0402]  71.6 76.79 270 top
RC126  1K_0402_5%  [R_0402]  76.3 75.9 90 top
RC128  0_0402_5%  [R_0402]  64.87 76.74 270 top
RC129  0_0402_5%  [R_0402]  65.89 76.74 270 top
RC130  51_0402_5%  [R_0402]  116.82 78.06 270 top
RC131  51_0402_5%  [R_0402]  90.91 76.46 90 bottom
RC132  150_0402_5%  [R_0402]  76.43 79.33 270 top
RC133  1.5K_0402_5%  [R_0402]  63.98 75.83 90 top
RC134  51_0402_5%  [R_0402]  89.95 76.46 90 bottom
RC135  51_0402_5%  [R_0402]  89 76.46 90 bottom
RC136  51_0402_5%  [R_0402]  79.49 73.49 180 bottom
RC137  1K_0402_5%  [R_0402]  65.89 70.19 270 bottom
RC138  51_0402_5%  [R_0402]  77.45 76.87 270 top
RC139  51_0402_5%  [R_0402]  63.09 76.74 270 top
RC140  100_0402_1%  [R_0402]  135.46 72.13 270 top
RC141  100_0402_1%  [R_0402]  136.34 71.22 90 top
RC143  0_0603_5%  [R0603_0OHM]  140.31 70.82 90 top
RC152  56_0402_1%  [R_0402]  116.18 78.06 180 bottom
RC153  220_0402_5%  [R_0402]  115.42 76.21 90 bottom
RC154  0_0402_1%  [R0402_0OHM]  114.53 76.21 90 bottom
RC155  0_0402_1%  [R0402_0OHM]  114.28 76.21 90 top
RC157  100_0402_1%  [R_0402]  113.64 77.12 270 bottom
RC158  100_0402_1%  [R_0402]  113.39 78.01 270 top
RC161  100_0402_1%  [R_0402]  111.18 67.01 180 top
RC163  100_0402_1%  [R_0402]  107.59 67.01 0 top
RC165  100_0402_1%  [R_0402]  137.39 57.24 270 top
RC166  100_0402_1%  [R_0402]  140.06 67.27 0 top
RC167  100_0402_1%  [R_0402]  138.28 56.35 90 top
RC168  100_0402_1%  [R_0402]  139.93 69.5 270 top
RC169  0_0402_1%  [R0402_0OHM]  145.2 75.79 270 top
RC170  0_0603_5%~D  [R0603_0OHM]  144.76 72.22 180 top
RC171  0_0402_1%  [R0402_0OHM]  130.02 57.18 270 top
RC172  0_0402_5%~D  [R_0402]  159.87 60.16 90 top
RC175  2.2K_0402_5%  [R_0402]  150.22 75.65 90 top
RC176  2.2K_0402_5%  [R_0402]  155.68 66.63 0 top
RC177  2.2K_0402_5%  [R_0402]  155.68 67.52 0 top
RC178  2.2K_0402_5%  [R_0402]  149.33 75.65 90 top
RC183  8.2K_0402_5%  [R_0402]  151.39 52.47 180 top
RC184  8.2K_0402_5%  [R_0402]  150.67 54.7 180 top
RC185  10K_0402_5%  [R_0402]  149.33 75.7 90 bottom
RC186  4.7K_0402_5%  [R_0402]  150.8 53.68 180 top
RC187  4.7K_0402_5%  [R_0402]  141.07 45.3 90 top
RC188  10K_0402_5%  [R_0402]  150.34 75.7 90 bottom
RC189  10K_0402_5%  [R_0402]  148.44 75.7 90 bottom
RC190  10K_0402_5%  [R_0402]  202.29 19.52 270 top
RC191  10K_0402_5%  [R_0402]  147.55 75.7 90 bottom
RC211  0_0603_5%~D  [R0603_0OHM]  148.44 58.33 180 top
RC213  0_0402_1%  [R0402_0OHM]  146.15 58.25 180 top
RC214  0_0603_5%~D  [R0603_0OHM]  157.46 44.66 0 top
RC215  0_0402_5%  [R_0402]  144.63 44.51 90 bottom
RC216  0_0603_5%~D  [R0603_0OHM]  69.06 69.62 90 bottom
RC217  0_0402_5%  [R_0402]  75.54 79.33 270 top
RC218  150_0402_5%  [R_0402]  72.8 79.08 0 top
RC219  10K_0402_5%  [R_0402]  74.65 78.44 90 top
RC220  100K_0402_5%~D  [R_0402]  143.1 42.88 270 top
RC221  0_0402_1%  [R0402_0OHM]  177.14 64.4 90 bottom
RC224  1K_0402_5%  [R_0402]  153.52 72.09 270 top
RC225  8.2K_0402_5%  [R_0402]  159.11 72.09 180 top
RC226  0_0402_5%  [R_0402]  161.9 62.87 90 top
RC227  8.2K_0402_5%  [R_0402]  158.22 71.08 0 top
RC228  0_0402_1%  [R0402_0OHM]  185.65 41.92 90 bottom
RC229  0_0402_5%  [R_0402]  186.54 41.92 90 bottom
RC230  0_0402_5%  [R_0402]  185.52 41.31 270 top
RC232  0_0603_5%  [R0603_0OHM]  115.6 69.39 0 top
RC236  10K_0402_5%  [R_0402]  152.38 76.62 270 bottom
RC237  10K_0402_5%  [R_0402]  148.69 49.87 90 top
RC239  0_0402_5%  [R_0402]  74.02 76.79 270 top
RC240  0_0402_5%  [R_0402]  73 76.79 270 top
RC241  1.5K_0402_5%  [R_0402]  69.7 76.79 270 top
RC242  100K_0402_5%  [R_0402]  149.65 67.5 270 top
RC243  10K_0402_5%  [R_0402]  144.91 47.46 270 top
RC245  10K_0402_5%  [R_0402]  149.2 45.5 270 bottom
RC246  10K_0402_5%  [R_0402]  156.73 49.05 180 bottom
RC247  0_0402_1%  [R0402_0OHM]  148.31 70.62 90 top
RC248  0_0402_1%  [R0402_0OHM]  155.68 70.95 0 bottom
RC272  10K_0402_5%  [R_0402]  156.73 48.17 180 bottom
RC277  10K_0402_5%  [R_0402]  151.49 76.62 270 bottom
RC280  100K_0402_5%~D  [R_0402]  155.68 61.43 0 top
RC283  10K_0402_5%  [R_0402]  156.57 58.12 180 bottom
RC284  4.7K_0402_5%  [R_0402]  158.9 59.78 0 bottom
RC285  4.7K_0402_5%  [R_0402]  158.9 60.66 0 bottom
RC288  100K_0402_5%~D  [R_0402]  156.57 47.08 180 bottom
RC290  0_0402_1%  [R0402_0OHM]  156.44 69.94 180 top
RC291  10K_0402_5%  [R_0402]  152.63 72.09 270 top
RC292  10K_0402_5%  [R_0402]  156.59 59.95 180 bottom
RC293  10K_0402_5%  [R_0402]  22.76 53.81 0 top
RC296  0_0402_1%  [R0402_0OHM]  150.47 46.82 0 top
RC297  0_0402_1%  [R0402_0OHM]  90.65 80.22 180 top
RC298  0_0402_1%  [R0402_0OHM]  90.65 79.33 180 top
RC299  0_0603_5%~D  [R0603_0OHM]  151.61 69.68 270 top
RC301  0_0402_1%  [R0402_0OHM]  156.59 65.9 180 bottom
RC304  0_0603_5%~D  [R0603_0OHM]  151.87 59.65 180 top
RC309  0_0603_5%~D  [R0603_0OHM]  147.3 76.79 270 top
RC310  0_0402_1%  [R0402_0OHM]  148.44 76.54 270 top
RC312  100K_0402_5%  [R_0402]  148.76 67.5 270 top
RD17  8.2K_0402_1%  [R_0402]  100.56 42.63 90 top
RD19  8.2K_0402_1%  [R_0402]  101.45 43.52 270 top
RD21  8.2K_0402_1%  [R_0402]  102.59 39.33 0 top
RD22  8.2K_0402_1%  [R_0402]  155.93 38.31 180 top
RD25  8.2K_0402_1%  [R_0402]  103.48 38.44 180 top
RD26  8.2K_0402_1%  [R_0402]  153.9 37.42 180 top
RD35  37.4_0402_1%~D  [R_0402]  101.27 20.17 270 top
RD36  37.4_0402_1%~D  [R_0402]  134.85 20.15 270 top
RD37  37.4_0402_1%~D  [R_0402]  102.15 20.17 270 top
RD38  37.4_0402_1%~D  [R_0402]  133.96 20.15 270 top
RD45  37.4_0402_1%~D  [R_0402]  121.51 20.15 270 top
RD46  37.4_0402_1%~D  [R_0402]  122.4 20.15 270 top
RD47  37.4_0402_1%~D  [R_0402]  152.12 20.15 270 top
RD48  37.4_0402_1%~D  [R_0402]  153.01 20.15 270 top
RD51  240_0402_1%  [R_0402]  97.2 22.84 180 top
RD52  240_0402_1%  [R_0402]  116.05 20.15 270 top
RD53  240_0402_1%  [R_0402]  97.2 24.74 180 top
RD54  240_0402_1%  [R_0402]  115.16 20.15 270 top
RD55  240_0402_1%  [R_0402]  146.28 20.15 270 top
RD56  240_0402_1%  [R_0402]  145.39 20.15 270 top
RD57  240_0402_1%  [R_0402]  131.04 24.22 180 top
RD58  240_0402_1%  [R_0402]  131.04 25.49 180 top
RD59  68_0402_1%  [R_0402]  111.48 20.15 270 top
RD60  68_0402_1%  [R_0402]  141.07 20.15 270 top
RD61  68_0402_1%  [R_0402]  110.59 20.15 270 top
RD62  68_0402_1%  [R_0402]  140.18 20.15 270 top
RD63  68_0402_1%  [R_0402]  108.81 20.15 270 top
RD64  68_0402_1%  [R_0402]  138.41 20.15 270 top
RD65  68_0402_1%  [R_0402]  109.7 20.15 270 top
RD66  68_0402_1%  [R_0402]  139.29 20.15 270 top
RD67  68_0402_1%  [R_0402]  107.93 20.15 270 top
RD68  68_0402_1%  [R_0402]  137.52 20.15 270 top
RD69  68_0402_1%  [R_0402]  100.38 20.17 270 top
RD70  68_0402_1%  [R_0402]  133.07 20.15 270 top
RD71  68_0402_1%  [R_0402]  98.6 20.17 270 top
RD72  68_0402_1%  [R_0402]  131.29 20.15 270 top
RD73  68_0402_1%  [R_0402]  99.49 20.17 270 top
RD74  68_0402_1%  [R_0402]  132.18 20.15 270 top
RD75  68_0402_1%  [R_0402]  97.71 20.17 270 top
RD76  68_0402_1%  [R_0402]  130.4 20.15 270 top
RD77  68_0402_1%  [R_0402]  96.82 20.17 270 top
RD78  68_0402_1%  [R_0402]  129.52 20.15 270 top
RD79  68_0402_1%  [R_0402]  128.63 20.15 270 top
RD80  68_0402_1%  [R_0402]  159.23 20.15 270 top
RD81  68_0402_1%  [R_0402]  127.74 20.15 270 top
RD82  68_0402_1%  [R_0402]  158.34 20.15 270 top
RD83  68_0402_1%  [R_0402]  125.96 20.15 270 top
RD84  68_0402_1%  [R_0402]  156.57 20.15 270 top
RD85  68_0402_1%  [R_0402]  126.85 20.15 270 top
RD86  68_0402_1%  [R_0402]  157.46 20.15 270 top
RD87  68_0402_1%  [R_0402]  125.07 20.15 270 top
RD88  68_0402_1%  [R_0402]  155.68 20.15 270 top
RD89  68_0402_1%  [R_0402]  120.63 20.15 270 top
RD90  68_0402_1%  [R_0402]  151.23 20.15 270 top
RD91  68_0402_1%  [R_0402]  119.74 20.15 270 top
RD92  68_0402_1%  [R_0402]  149.45 20.15 270 top
RD93  68_0402_1%  [R_0402]  118.85 20.15 270 top
RD94  68_0402_1%  [R_0402]  150.34 20.15 270 top
RD95  68_0402_1%  [R_0402]  117.93 20.17 270 top
RD96  68_0402_1%  [R_0402]  148.57 20.15 270 top
RD97  68_0402_1%  [R_0402]  117.04 20.17 270 top
RD98  68_0402_1%  [R_0402]  147.68 20.15 270 top
RD99  80.6_0402_1%~D  [R_0402]  112.37 20.15 270 top
RD100  80.6_0402_1%~D  [R_0402]  144.5 20.15 270 top
RD101  80.6_0402_1%~D  [R_0402]  113.36 20.17 270 top
RD102  80.6_0402_1%~D  [R_0402]  143.61 20.15 270 top
RD103  80.6_0402_1%~D  [R_0402]  107.04 20.15 270 top
RD104  80.6_0402_1%~D  [R_0402]  135.74 20.15 270 top
RD105  80.6_0402_1%~D  [R_0402]  103.04 20.17 270 top
RD106  80.6_0402_1%~D  [R_0402]  136.63 20.15 270 top
RD107  80.6_0402_1%~D  [R_0402]  124.18 20.15 270 top
RD108  80.6_0402_1%~D  [R_0402]  153.9 20.15 270 top
RD109  80.6_0402_1%~D  [R_0402]  123.29 20.15 270 top
RD110  80.6_0402_1%~D  [R_0402]  154.79 20.15 270 top
RD111  4.99_0402_1%~D  [R_0402]  103.23 43.52 180 top
RD112  24.9_0402_1%  [R_0402]  103.23 42.63 180 top
RD113  10_0402_1%~D  [R_0402]  105.26 39.33 180 top
RD114  10_0402_1%~D  [R_0402]  153.01 38.31 0 top
RD115  24.9_0402_1%  [R_0402]  103.48 40.22 180 top
RD116  24.9_0402_1%  [R_0402]  155.04 39.2 0 top
RD117  80.6_0402_1%~D  [R_0402]  114.24 20.17 270 top
RD118  80.6_0402_1%~D  [R_0402]  142.72 20.15 270 top
RE2  10K_0402_5%  [R_0402]  173.2 66.51 0 top
RE3  10K_0402_5%  [R_0402]  173.2 62.06 0 top
RE6  4.7K_0402_5%~D  [R_0402]  173.13 65.62 0 top
RE7  4.7K_0402_5%~D  [R_0402]  173.2 64.73 0 top
RE13  100K_0402_5%  [R_0402]  34.44 14.44 0 top
RE14  100K_0402_5%  [R_0402]  37.13 14.43 180 top
RE22  10K_0402_5%  [R_0402]  35.28 20.81 270 top
RE23  10K_0402_5%  [R_0402]  34.39 20.81 270 top
RE24  10K_0402_5%  [R_0402]  36.3 19.9 90 top
RE25  100K_0402_5%  [R_0402]  184.13 74.13 270 top
RE26  10_0402_5%  [R_0402]  183.24 74.13 270 top
RE27  10K_0402_5%  [R_0402]  33.38 19.9 90 top
RE31  100K_0402_5%  [R_0402]  188.95 52.41 90 top
RE32  0_0402_1%  [R0402_0OHM]  188.06 55.51 90 bottom
RE33  1K_0402_5%  [R_0402]  188.06 53.3 270 top
RE34  10K_0402_5%  [R_0402]  191.03 51.27 0 bottom
RE35  10K_0402_5%  [R_0402]  188.57 51.47 270 bottom
RE36  100K_0402_5%  [R_0402]  191.95 52.16 180 bottom
RE52  2.2K_0402_5%  [R_0402]  180.29 57.87 0 bottom
RE53  2.2K_0402_5%  [R_0402]  182.98 57.87 180 bottom
RE54  10K_0402_5%  [R_0402]  182.22 71.84 270 top
RE55  8.2K_0402_5%  [R_0402]  174.09 59.27 180 top
RE56  8.2K_0402_5%  [R_0402]  177.83 59.55 180 bottom
RE57  1K_0402_5%  [R_0402]  185.01 55.79 270 top
RE58  100K_0402_5%  [R_0402]  174.12 63.84 180 top
RE59  10K_0402_5%  [R_0402]  36.35 17.95 270 top
RE60  100K_0402_5%  [R_0402]  100.48 44.54 0 bottom
RE61  43_0402_5%  [R_0402]  176 57.11 270 bottom
RE62  0_0402_1%  [R0402_0OHM]  186.16 55.79 270 top
RE63  100K_0402_5%  [R_0402]  184.13 55.79 270 top
RE64  4.7K_0402_5%  [R_0402]  183.87 58.45 270 bottom
RE65  100K_0402_5%  [R_0402]  172.44 60.46 90 bottom
RE66  100_0402_1%  [R_0402]  173.33 61.38 270 bottom
RE67  10K_0402_5%  [R_0402]  190.65 60.28 0 top
RE68  100K_0402_5%  [R_0402]  173.2 68.39 0 top
RE69  8.2K_0402_5%  [R_0402]  177.06 70.95 0 top
RE70  2.2K_0402_5%  [R_0402]  177.39 72.09 180 top
RE71  2.2K_0402_5%  [R_0402]  190.65 61.17 0 top
RE72  10K_0402_5%  [R_0402]  173.08 64.86 90 bottom
RE73  2.2K_0402_5%  [R_0402]  187.17 61.3 0 bottom
RE74  10K_0402_5%  [R_0402]  175.29 64.96 90 bottom
RE75  100K_0402_5%  [R_0402]  173.97 64.86 90 bottom
RE76  49.9_0402_1%  [R_0402]  168.89 64.78 90 bottom
RE77  1.5K_0402_1%  [R_0402]  186.92 70.95 90 top
RE78  1K_0402_5%  [R_0402]  181.33 74.13 270 top
RE79  62K_0402_1%  [R_0402]  190.6 64.65 90 bottom
RE80  10_0402_5%  [R_0402]  180.19 70.95 90 top
RE81  10K_0402_5%  [R_0402]  189.51 58.34 270 bottom
RE82  10K_0402_5%  [R_0402]  187.73 58.12 0 bottom
RE83  10K_0402_5%  [R_0402]  185.65 73.36 0 top
RE84  100K_0402_5%  [R_0402]  188.06 72.35 0 top
RE85  10K_0402_5%  [R_0402]  172.31 61.05 180 top
RE86  10K_0402_5%  [R_0402]  187.17 62.17 0 bottom
RE87  2.2K_0201_5%  [R_0201]  177.31 61.63 90 bottom
RE88  2.2K_0201_5%  [R_0201]  177.31 60.96 270 bottom
RE89  10K_0402_5%  [R_0402]  38.41 14.87 270 top
RE90  100K_0402_5%  [R_0402]  28.78 45.46 270 top
RE91  10K_0402_5%  [R_0402]  195.48 48.6 0 top
RE92  0_0402_1%  [R0402_0OHM]  184.63 50.2 270 top
RE93  10K_0402_5%  [R_0402]  189.22 75.54 270 bottom
RE94  0_0402_5%~D  [R_0402]  187.41 75.49 0 bottom
RE95  0_0402_5%~D  [R_0402]  201.67 56.65 90 top
RE96  100_0402_5%  [R_0402]  174.09 60.16 180 top
RE97  100K_0402_5%  [R_0402]  200.71 56.65 90 top
RE98  0_0402_5%~D  [R_0402]  192.89 61.35 90 bottom
RE99  100K_0402_5%  [R_0402]  194.79 60.21 90 bottom
RE100  0_0402_5%~D  [R_0402]  55.2 43.52 270 top
RE101  100K_0402_5%  [R_0402]  56.16 43.52 270 top
RE102  100K_0402_5%  [R_0402]  189.04 69.05 180 bottom
RE103  100K_0402_5%  [R_0402]  198.08 54.5 0 top
RE104  0_0402_1%  [R0402_0OHM]  173.2 61.05 0 top
RE105  0_0402_1%  [R0402_0OHM]  177.14 63.08 0 bottom
RE107  0_0402_1%  [R0402_0OHM]  179.05 56.9 90 bottom
RE120  0_0402_1%  [R0402_0OHM]  46.25 35.95 90 bottom
RH24  1K_0402_5%~D  [R_0402]  158.73 50.25 180 top
RH56  1K_0402_5%~D  [R_0402]  174.4 45.42 0 bottom
RH58  1K_0402_5%~D  [R_0402]  174.4 44.54 0 bottom
RH59  1K_0402_5%~D  [R_0402]  156.52 50.76 180 bottom
RH126  10K_0201_5%  [R_0201]  190.89 44.03 180 top
RH127  100_0402_1%  [R_0402]  193.27 44.41 0 top
RH129  10K_0402_5%  [R_0402]  153.43 52.9 0 top
RH139  10K_0402_5%  [R_0402]  152.34 53.59 270 top
RH144  10K_0402_5%  [R_0402]  155.55 54.31 0 top
RH145  10K_0402_5%  [R_0402]  156.59 68.82 180 bottom
RH146  10K_0402_5%  [R_0402]  156.52 57.87 180 top
RH147  10K_0402_5%  [R_0402]  159.13 67.04 180 bottom
RH148  100K_0402_5%  [R_0402]  149.78 56.6 180 top
RH149  10K_0402_5%  [R_0402]  155.6 55.2 0 top
RH150  10K_0402_5%  [R_0402]  155.55 53.43 0 top
RH151  10K_0402_5%  [R_0402]  155.6 56.98 0 top
RH152  10K_0402_5%  [R_0402]  155.6 56.09 0 top
RH153  100K_0402_5%  [R_0402]  147.88 56.6 180 top
RH357  0_0603_5%~D  [R0603_0OHM]  69.7 78.63 90 top
RH438  1K_0402_5%~D  [R_0402]  55.36 71.22 180 bottom
RH440  100K_0402_5%~D  [R_0402]  158.22 64.98 0 bottom
RH441  100K_0402_5%~D  [R_0402]  158.22 63.97 0 bottom
RH442  SHORT PADS  [SHORTPADS]  161.01 64.98 0 bottom
RH443  SHORT PADS  [SHORTPADS]  161.01 63.71 0 bottom
RH456  0_0402_5%~D  [R_0402]  192.13 16.04 270 top
RH461  0_0402_5%~D  [R_0402]  188.57 15.83 90 top
RH556  100K_0402_5%~D  [R_0402]  155.65 59.01 0 bottom
RH557  100K_0402_5%~D  [R_0402]  158.47 80.22 0 top
RH562  49.9K_0402_1%  [R_0402]  48.95 22.16 270 bottom
RH563  49.9K_0402_1%  [R_0402]  48.95 19.49 90 bottom
RN19  2.2K_0402_5%  [R_0402]  158.65 66.38 0 top
RN20  2.2K_0402_5%  [R_0402]  158.8 62.32 180 top
RP5  33_8P4R_5%  [RP_0804_8P4R]  178.1 48.71 180 bottom
RP6  33_8P4R_5%  [RP_0804_8P4R]  178.1 45.92 180 bottom
RPE5  100K_0804_8P4R_5%  [RP_0804_8P4R]  191.24 59.01 0 top
RPE7  10K_8P4R_5%  [RP_0804_8P4R]  170.16 65.36 270 bottom
RT1  3.01K_0402_1%  [R_0402]  50.34 68.28 180 top
RT2  14K_0402_1%  [R_0402]  42.77 53.45 270 top
RT3  100_0201_1%  [R_0201]  39.04 52.88 90 top
RT4  100_0201_1%  [R_0201]  49.92 56.6 180 top
RT5  14K_0402_1%  [R_0402]  49.43 66.13 0 top
RT6  10K_0201_5%  [R_0201]  48.49 72.82 90 top
RT7  10K_0201_5%  [R_0201]  49.12 72.82 90 top
RT8  10K_0201_5%  [R_0201]  50.27 72.69 90 top
RT9  10K_0201_5%  [R_0201]  51.03 72.69 90 top
RT10  4.75K_0402_0.5%  [R_0402]  43.66 50.55 90 top
RT11  0_0201_5%  [R_0201]  36.82 67.51 0 top
RT12  499_0201_1%  [R_0201]  39.64 67.4 90 top
RT15  3.3K_0201_1%  [R_0201]  41.25 39.39 0 top
RT16  3.3K_0201_1%  [R_0201]  51.32 39.2 180 top
RT17  3.3K_0201_1%  [R_0201]  51.32 40.34 180 top
RT18  3.3K_0201_1%  [R_0201]  51.32 38.31 180 top
RT21  10K_0201_5%  [R_0201]  49.92 57.24 180 top
RT22  10K_0201_5%  [R_0201]  45.57 52.88 90 top
RT23  10K_0201_5%  [R_0201]  46.2 52.88 90 top
RT25  10K_0201_5%  [R_0201]  39.6 52.88 90 top
RT26  10K_0201_5%  [R_0201]  37.15 52.28 0 top
RT33  2.2K_0201_5%  [R_0201]  47.47 52.88 90 top
RT34  2.2K_0201_5%  [R_0201]  46.84 52.88 90 top
RT35  2.2K_0201_5%  [R_0201]  43.66 52.88 90 top
RT36  2.2K_0201_5%  [R_0201]  44.3 52.88 90 top
RT37  100K_0201_5%  [R_0201]  44.93 52.88 90 top
RT38  100K_0201_5%  [R_0201]  44.55 51.47 270 top
RT39  100K_0201_5%  [R_0201]  40.44 52.88 90 top
RT40  100K_0201_5%  [R_0201]  32.58 55.97 0 top
RT43  100K_0201_5%  [R_0201]  45.82 50.89 90 top
RT44  1M_0201_1%  [R_0201]  34.39 57.62 0 top
RT45  1M_0201_1%  [R_0201]  34.39 56.98 0 top
RT46  0_0402_5%~D  [R_0402]  33.12 57.87 180 top
RT47  10K_0201_5%  [R_0201]  45.19 51.47 270 top
RT48  100K_0201_5%  [R_0201]  33.02 62.38 270 top
RT49  100K_0201_5%  [R_0201]  36.93 47.24 270 top
RT50  100K_0201_5%  [R_0201]  32.39 62.38 270 top
RT51  10K_0201_5%  [R_0201]  33.35 48.19 180 top
RT52  10K_0201_5%  [R_0201]  33.88 55.36 90 top
RT113  0_0402_5%~D  [R_0402]  33.12 56.98 180 top
RT114  0.01_0603_1%  [R_0603]  46.84 48.24 180 top
RT119  0_0201_5%  [R_0201]  38.46 52.88 90 top
RT120  0_0201_5%  [R_0201]  28.93 46.21 90 top
RT121  0_0201_5%  [R_0201]  29.62 46.18 90 top
RT164  499_0201_1%  [R_0201]  39.04 67.98 270 top
RT187  100K_0201_5%  [R_0201]  18.81 63.31 180 top
RT188  100K_0201_5%  [R_0201]  18.81 63.86 180 top
RT190  0_0402_5%  [R_0402]  23.65 66.25 90 top
RT199  0_0402_5%  [R_0402]  22.47 57.62 180 bottom
RT200  0_0402_5%  [R_0402]  22.34 59.01 180 bottom
RT201  0_0402_5%  [R_0402]  18.78 68.7 270 top
RT241  0_0603_5%~D  [R_0603]  24.68 46.47 90 bottom
RT242  0_0402_5%~D  [R_0402]  179.82 53.9 180 top
RTCR1  1.3K_0402_5%~D  [R_0402]  13.74 8.85 0 top
RZ75  100K_0402_5%  [R_0402]  167.54 67.78 0 top
RZ76  0_0402_1%  [R0402_0OHM]  166.85 48.85 180 top
SW1  SSAL120100_3P  [SW_SSAL120100_3P]  166.09 48.66 180 bottom
SW2  SKRBAAE010_4P  [SW_SKRBAAE010_4P]  191.75 76.11 90 top
SW3  TBFD12KQR_4P  [SW_NTC311-EA1T-A160T_4P]  3.52 23.28 270 top
T1  PAD~D  [TPC12]  124.81 67.89 0 top
T2  PAD~D  [TPC12]  124.8 70.67 0 top
T7  PAD~D  [TPC12]  122.93 54.05 0 top
T8  PAD~D  [TPC12]  127.53 54.03 0 top
T9  PAD~D  [TPC12]  109.06 73.38 0 top
T10  PAD~D  [TPC12]  121 75.69 180 bottom
T11  PAD~D  [TPC12]  119.99 74.51 180 bottom
T12  PAD~D  [TPC12]  112.38 41.98 180 bottom
T13  PAD~D  [TPC12]  111.2 45.11 180 bottom
T14  PAD~D  [TPC12]  144.87 55.56 0 top
T15  PAD~D  [TPC12]  146.03 56.6 0 top
T16  PAD~D  [TPC12]  110.85 46.69 180 bottom
T17  PAD~D  [TPC12]  112.24 43.61 180 bottom
T18  PAD~D  [TPC12]  144.79 51.65 0 top
T19  PAD~D  [TPC12]  124.56 47.71 180 bottom
T21  PAD~D  [TPC12]  127.48 55.33 0 top
T113  PAD~D  [TPC12]  110.49 41.96 180 bottom
T114  PAD~D  [TPC12]  110.67 43.61 180 bottom
T115  PAD~D  [TPC12]  145.83 52.82 0 top
T116  PAD~D  [TPC12]  143.04 53.48 0 top
T121  PAD~D  [TPC12]  153.01 46.69 180 bottom
T122  PAD~D  [TPC12]  133.91 66.53 0 top
T123  PAD~D  [TPC12]  133.63 57.03 0 top
T124  PAD~D  [TPC12]  154.16 59.03 180 bottom
T125  PAD~D  [TPC12]  149.58 57.94 0 top
T126  PAD~D  [TPC12]  156.45 49.9 180 bottom
T127  PAD~D  [TPC12]  155.04 49.9 180 bottom
T128  PAD~D  [TPC12]  154.09 52.77 180 bottom
T129  PAD~D  [TPC12]  153.81 54.78 180 bottom
T130  PAD~D  [TPC12]  154.95 48.18 180 bottom
T183  PAD~D  [TPC12]  189.21 64.09 0 top
T184  PAD~D  [TPC12]  183.49 69.81 0 top
T185  PAD~D  [TPC12]  181.46 56.73 0 top
T187  PAD~D  [TPC12]  184 68.67 180 bottom
T188  PAD~D  [TPC12]  178.03 63.97 180 bottom
T189  PAD~D  [TPC12]  184.32 61.38 180 bottom
T192  PAD~D  [TPC12]  142.01 42.63 180 bottom
T193  PAD~D  [TPC12]  29.29 59.4 180 bottom
T194  PAD~D  [TPC12]  28.07 58.97 180 bottom
T195  PAD~D  [TPC12]  116.92 56.93 0 top
T196  PAD~D  [TPC12]  118.21 56.73 0 top
T197  PAD~D  [TPC12]  179.06 55.92 180 bottom
TC25  PAD~D  [TPC12]  22.2 68.16 0 top
TC29  PAD~D  [TPC12]  20.57 68.25 0 top
TC35  PAD~D  [TPC12]  26.14 65.89 0 top
TC36  PAD~D  [TPC12]  22.79 58.05 0 top
TC38  PAD~D  [TPC12]  22.59 56.78 0 top
U15  NPCT650JA0YX  [NPCT650JAAYX_QFN32_5X5]  183.11 47.08 0 top
U18  W25Q256FVEIQ_WSON8  [W25Q256FVEIG_WSON8]  185.01 46.94 180 bottom
U48  -  [PCA9515BDGKR_VSSOP8]  202.33 25.22 0 top
U664  AOZ1331_DFN_14P  [TPS22966DPUR_SON14_2X3]  34.32 42.89 180 top
U683  S IC TC7SZ14FU SSOP 5P  [NL17SZ14DFT2G_SOT353-5]  186.92 39.33 90 bottom
U699  MC74VHC1G32DFT2G_SC70-5~D  [MC74VHC1G32DFT2G_SC70-5]  25.5 53.81 180 top
U716  AOZ1331_DFN_14P  [TPS22966DPUR_SON14_2X3]  170.1 16.33 0 top
U717  AOZ1331_DFN_14P  [TPS22966DPUR_SON14_2X3]  180.88 33.5 180 top
U719  AOZ1331_DFN_14P  [TPS22966DPUR_SON14_2X3]  51.93 18.95 90 top
U720  AOZ1331_DFN_14P  [TPS22966DPUR_SON14_2X3]  35.73 41.48 0 top
U722  TPS65982_BGA96  [TPS65982_BGA_96P]  26.01 64.47 270 top
U728  -  [G9091-330TO1U_TSOT-23-5]  64.97 80.16 270 top
U729  -  [MC74VHC1G09DFT2G_SC70-5]  189.32 77.84 270 bottom
UA2  -  [ALC3246-CG_MQFN48_6X6]  30.71 27.48 180 top
UC2  SN74AUP1G07DCKR_SC70  [74AUP1G07GW_TSSOP5]  104.63 46.2 270 bottom
UC7  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  161.14 59.78 0 top
UC8  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  204.05 58.03 180 top
UC9  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  164.38 70.33 270 top
UC10  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  191.3 59 90 bottom
UC11  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  52.8 42.24 0 top
UC12  -  [74AHC1G09GW_TSSOP5]  156.69 70.95 90 top
UC13  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  199.51 57.49 180 top
UCPU1  SKL-U_BGA1356  [SKL-U_BGA_1356P-T]  152.12 72.31 0 bottom
UD19  H9CCNNN8JTMLAR-NTM_FBGA178~D  [H9CCNNN8JTMLAR-NTM_FBGA_178P]  99.62 23.5 90 top
UD20  H9CCNNN8JTMLAR-NTM_FBGA178~D  [H9CCNNN8JTMLAR-NTM_FBGA_178P]  115.14 23.5 90 top
UD21  H9CCNNN8JTMLAR-NTM_FBGA178~D  [H9CCNNN8JTMLAR-NTM_FBGA_178P]  133.2 23.5 90 top
UD22  H9CCNNN8JTMLAR-NTM_FBGA178~D  [H9CCNNN8JTMLAR-NTM_FBGA_178P]  148.77 23.5 90 top
UE4  -  [MCP23017T-E-ML_QFN28_6X6]  30.96 15.58 90 bottom
UE5  MEC5085-LZY  [MEC5085-LZY_DQFN132_11X11]  188.06 59.52 90 top
US2  -  [G547I1P81U_MSOP8]  24.36 49.23 90 top
UT1  AR-A1_BGA337  [AR-4C_BGA_337P-T]  37.44 55.46 270 top
UT5  -  [W25Q80DVZPIG_WSON8]  49.15 38.31 90 top
UT6  W25Q64FVZPIQ  [W25Q64FVZPIG_WSON8_6X5]  20.42 40.44 0 top
UZ19  -  [TPS22961DNYR_WSON8]  166.17 65.78 90 top
UZ22  -  [TPS22961DNYR_WSON8]  164.81 46.84 90 top
UZ23  -  [TPS22961DNYR_WSON8]  50.73 49.53 90 top
UZ24  -  [SY6288C20AAC_SOT23-5]  201.91 40.98 90 top
UZ25  -  [TPS22961DNYR_WSON8]  157.2 74.38 90 top
UZ26  -  [TPS22961DNYR_WSON8]  57.12 75.73 0 top
YC1  24MHZ_12PF_X3G024000DC1H  [Y_X3G024000DC1H_4P]  133.71 76.79 180 top
YC2  9PF 20PPM 9H03280012  [Y_9H03220008_2P]  152.88 44.28 180 top
YE1  32.768KHZ 9PF 20PPM 9H03200033  [Y_Q13FC135000040_2P]  184.38 51.9 0 top
YT1  25MHZ_10PF_7V25000014  [Y_7V25000014_4P]  33.29 68.45 0 top

## Library data of the parts
C2-C7 C265 C352 C355 C375-C377 C397 C398 C401 C402 C612-C617 C621 C623 C713 C715 C720-C722 C963 C1060-C1069 C1102 C1145 C1158-C1164 C1166-C1169 C1199-C1201 C1203 C1204 C1208 C1211-C1218 C1220-C1223 C1225 C1226 C1229 C1254 C1256-C1258 C1264 C1273-C1275 C1278-C1280 C1289 C1292 C1293 C1297 C1298 C1301 C1302 C1304 C1309 C1321 C1322 C1324 C1325 C1346 C2973 C2983 CA3 CA4 CA7 CA23-CA25 CA27-CA35 CA40 CA42 CA53-CA56 CA68-CA72 CA78 CA80 CA87 CA97 CA100 CA103-CA106 CA111 CC4 CC5 CC8 CC10 CC21-CC29 CC32 CC33 CC174-CC180 CC184 CC187 CC194 CC195 CC199 CC202-CC206 CC209 CC211-CC214 CC217 CC218 CC220 CC223 CC224 CC240 CC248-CC253 CC264-CC270 CD1 CD3 CD5 CD7 CD29 CD33 CD37 CD39 CD41 CD43-CD47 CD51 CD53 CD57 CD59 CD61 CD63 CD85 CD87 CD89 CD91 CD117-CD120 CD129 CD132 CD133 CD135 CD136 CD139 CD140 CD142-CD146 CD148-CD181 CD183-CD187 CE3 CE10 CE13 CE14 CE17 CE21 CE22 CE38-CE41 CE43 CE46-CE68 CE72 CH11-CH14 CH95 CS44 CT43 CT44 CT53-CT56 CT95-CT98 CT144 CT151 CT152 CZ78 CZ82-CZ87 CZ89-CZ92 MC3 PC100-PC102 PC104-PC107 PC203-PC205 PC210-PC218 PC301 PC310 PC311 PC318 PC330-PC332 PC334-PC336 PC400-PC403 PC405 PC406 PC500 PC501 PC511 PC513 PC514 PC525 PC602-PC607 PC609 PC614 PC617 PC618 PC700-PC702 PC704 PC707 PC800 PC801 PC803 PC804 PC806 PC807 PC900 PC901 PC903 PC904 PC906 PC907 PC1004 PC1006 PC1014 PC1019-PC1022 PC1056 PC1064 PC1065 PC1067-PC1072 PC1074-PC1081 PC1083-PC1085 PC1087-PC1092 PC1094-PC1099 PC1103 PC1104 PC1110-PC1114 PC1117-PC1119 PC1123 PC1124 PC1127-PC1129 PC1131-PC1134 PC1237 PC1400 PC1408-PC1412 PC1417-PC1420 PC1500 PC1508-PC1512 PC1517-PC1520 = C_0402
C8 C94 C712 C716 C719 C962 C1143 C1205 C1339 C1341 C1347-C1350 C1353 C2982 CA74 CA82 CA83 CA86 CA107-CA110 CC31 CC34 CC35 CC279 CC280 CD2 CD4 CD6 CD8 CD30 CD34 CD38 CD42 CD58 CD60 CD62 CD64 CD86 CD88 CD90 CD92 CD147 CD182 CD196 CD197 CE4 CE42 CE45 CT9 CT88-CT90 CT164 CT165 PC103 PC200-PC202 PC206-PC209 PC309 PC312 PC316 PC319 PC320 PC322 PC323 PC333 PC337 PC404 PC407 PC504-PC510 PC512 PC517-PC524 PC526 PC527 PC600 PC601 PC608 PC610-PC613 PC615 PC616 PC703 PC712 PC713 PC1005 PC1007 PC1082 PC1086 PC1106 PC1115 PC1116 PC1125 PC1126 PC1130 PC1200-PC1236 PC1238-PC1258 PC1310-PC1321 PC1330-PC1337 PC1344-PC1354 PC1401-PC1406 PC1413-PC1416 PC1501-PC1506 PC1513-PC1516 = C_0603
C95-C98 C135 C618 C1345 C1354 CC125 CC181-CC183 CC185 CC186 CC188-CC192 CC225 CC256-CC261 CE70 CE71 CT1-CT8 CT17-CT26 CT29-CT42 CT47 CT50 CT52 CT57 CT62-CT68 CT71 CT72 CT74 CT80 CT81 CT83-CT86 CT91-CT94 CT99-CT103 CT107 CT108 CT163 PC1259-PC1305 PC1322-PC1328 PC1338-PC1343 = C_0201
C303 PC1306-PC1309 PC1329 PC1355 = C_B2
CA2 CA5 CA6 CA98 CA99 CA101 CA102 CA112 CC210 CC271-CC274 PC108 PC302-PC307 PC313-PC315 PC317 PC321 PC324-PC329 PC502 PC503 PC515 PC516 PC528 PC529 PC705 PC706 PC708-PC711 PC802 PC805 PC902 PC905 PC1066 PC1093 PC1100-PC1102 PC1105 PC1107-PC1109 PC1120-PC1122 = C_0805
CMOS1 JTAG1 RH442 RH443 = SHORTPADS: User Part Number: PART#
D72 D73 D94 = BAT54CW-7-F_SOT323-3
D75-D80 D82-D91 = ESD101-B1-02ELS_TSSLP-2-4-2
D81 DE11 DZ1-DZ3 = RB751S40T1G_SOD523-2
D122 = BAS40-04_SOT23-3
D123 = BZT52C15LP-7_DFN1006-2
DA1 DA2 = AZ5125-02SPR7G_SOT23-3
DA3 DA4 = PJDLC05C_SOT23-3
DA5 DA7 = ESD207-B1-02EL_TSLP-2-19-2
DI1 = IP4292CZ10-TBR_XSON10_2P5X1
DI2-DI4 = AZC199-02SPR7G_SOT23-3
DI7 = PESD24VS2UT_SOT23-3
FD1-FD4 = FIDUCIAL_C40M80
H1 H4 H7 H9 H12 H13 H18 H19 = H_2P0
H3 = H_1P8N
H6 H10 H11 H14-H17 = H_3P3
H20-H22 H24 H25 = EMIST_SUL-12A2M_1P
H23 = H_2P3X1P8N
H26 = H_3P2X0P8
JAPS1 = ACES_50506-01841-P01_18P
JAR1 JFAN1 JSPK1 = ACES_50224-00401-001_4P
JBATT1 = FOX_GS73091-10272-7H_9P-T
JCAM JTS = CVILU_CI1806M2HRP-NH_6P
JDEG1 JLPDE1 = HB_A531015-SCHR21_10P
JEDP = ACES_50398-04041-001_40P
JHP1 = SINGA_2SJ3095-022111F_6P-T
JIO1 = JXT_FP270H-061G1AM_61P
JKB1 = E-T_6710K-Y15M-31L_15P
JNGFF1 = CONCR_213AAAA32FA_67P
JNGFF2 = CONCR_213MAAA32FA_67P-T
JP100 = ACES_88266-05001_5P
JPA1-JPA3 PJP14 PJP15 PJP300 PJP601 PJP800 PJP900 = JUMP_43X39
JRTC1 = ACES_50278-00201-001_2P
JSPI1 = ACES_50696-0200M-P01_20P
JTP1 = ACES_50506-00841-P01_8P
JUART = ACES_50207-00471-P01_4P-T
JUSB2 = TE_C-PT13-067_9P-T
JUSBC1 = JAE_DX07SA24XJ2_24P-T
JXDP1 = SAMTE_BSH-030-01-L-D-A_60P
L2-L5 = MURAT_BLM15PX181SN1D_2P
L55 ML9-ML11 = INPAQ_MCM1012B900F06BP_4P
LA2 LA4 = MURAT_BLM15PX600SN1D_2P
LA3 = MURAT_BLM21PG600SN1D_L0805_2P
LA6 LA7 = CHILI_PBY100505T-600Y-N_2P
LA14 = MURAT_BLM15BB220SN1D_2P
LED10-LED14 = LED_27-11-T1D-CP1Q1RY-3C_2P
LT1 = COILC_XFL4012-601MEC_2P
LT14 = CHILI_PBY160808T-300Y-N_2P
LT106 PL100 PL101 PL103 PL104 PL300 PL500 PL600 PL700 PL1004 = TAI-T_HCB2012KF-121T50_2P
MD9 MD10 = PESD5V0U2BT_SOT23-3
ML6 ML7 = MURAT_DLW21HN900SQ2L_4P
ML12 ML13 = MURAT_DLW21SN670HQ2L_4P
PC1073 PC1135 = C_D
PD100 PD101 = TVNST52302AB0_SOT523-3
PD102 = AZ5125-01HPR7G_SOD523-2
PD200 = BAT54CW_SOT323-3
PD201-PD206 PD300-PD302 = SDMK0340L-7-F_SOD323-2
PH1005-PH1009 PR100-PR106 PR108 PR201-PR230 PR232-PR291 PR301 PR305 PR307 PR310 PR312 PR316 PR317 PR320 PR322 PR323 PR325 PR327 PR400-PR413 PR502 PR504 PR506 PR508 PR509 PR511 PR600 PR601 PR603-PR605 PR608 PR610 PR611 PR700 PR701 PR704 PR705 PR707 PR708 PR800 PR802 PR804 PR805 PR901 PR902 PR904 PR905 PR1028 PR1058 PR1060-PR1065 PR1067-PR1075 PR1077-PR1079 PR1081 PR1084 PR1085 PR1087-PR1090 PR1092-PR1099 PR1104 PR1107-PR1110 PR1112 PR1115 PR1117 PR1118 PR1120-PR1124 PR1126-PR1128 PR1402 PR1404-PR1408 PR1412-PR1415 PR1417 PR1418 PR1422-PR1425 PR1500 PR1502-PR1504 PR1506-PR1508 PR1511 PR1513-PR1515 PR1517-PR1523 PR1525-PR1527 PR1530 PR1531 R7 R78-R81 R220 R249 R252 R287 R288 R290-R292 R535 R536 R540 R545 R884 R886 R910-R913 R916 R1027 R1103-R1105 R1140 R1141 R1161 R1162 R1175 R1176 R1178 R1179 R1186-R1188 R1191 R1216 R1255 R1299 R1376 R1377 R1443 R1446 R1454 R1460 R1462 R1468 R1472-R1478 R2662 RA15-RA20 RA24 RA25 RA27 RA28 RA35 RA37-RA39 RA41 RA48-RA51 RA57 RA58 RA60-RA62 RA75-RA77 RC1-RC7 RC9-RC18 RC20-RC23 RC25-RC27 RC29 RC44-RC50 RC52-RC67 RC69 RC71-RC75 RC77-RC96 RC109 RC110 RC112-RC115 RC120-RC124 RC126 RC128-RC141 RC152 RC153 RC157 RC158 RC161 RC163 RC165-RC168 RC172 RC175-RC178 RC183-RC191 RC215 RC217-RC220 RC224-RC227 RC229 RC230 RC236 RC237 RC239-RC243 RC245 RC246 RC272 RC277 RC280 RC283-RC285 RC288 RC291-RC293 RC312 RD17 RD19 RD21 RD22 RD25 RD26 RD35-RD38 RD45-RD48 RD51-RD118 RE2 RE3 RE6 RE7 RE13 RE14 RE22-RE27 RE31 RE33-RE36 RE52-RE61 RE63-RE86 RE89-RE91 RE93-RE103 RH24 RH56 RH58 RH59 RH127 RH129 RH139 RH144-RH153 RH438 RH440 RH441 RH456 RH461 RH556 RH557 RH562 RH563 RN19 RN20 RT1 RT2 RT5 RT10 RT46 RT113 RT190 RT199-RT201 RT242 RTCR1 RZ75 = R_0402
PJP500 PJP501 PJP600 PJP1002 = JUMP_43X118
PJP700 PJP1400 PJP1401 = JUMP_43X79
PL102 = MURAT_BLM15AG102SN1D_2P
PL301 = L_7X7X3_M_2P
PL501 = TAI-T_TMPC0518HP-1R5MG-D_2P
PL504 = CYNTE_PCMC063T-1R5MN_2P
PL601 = CYNTE_PCMB051B-1R0MS_2P
PL701 PL1005 = L_5X5X3_M_2P
PL800 PL900 PL1400 PL1402 PL1500 PL1502 = TAI-T_HCB1608KF-121T3_L0603_2P
PL801 PL901 = TOKO_1239AS-H-2R2N-P2_2P
PL1100-PL1102 = NEC_MPC0740LR42C_2P
PL1401 PL1403 PL1501 PL1503 = TOKO_1277AS-H-1R0N-P2_2P
PQ100 = FDV301N_NL_SOT23-3
PQ101 QE9 = MMST3904-7-F_SOT323-3
PQ200-PQ203 PQ210-PQ212 = AON2405_DFN6-8
PQ204 PQ205 PQ213 PQ214 PQ221 PQ222 = NTR4502PT1G_SOT23-3
PQ206-PQ209 PQ215-PQ219 PQ223 PQ400 QA1 QA3 QC2 QE12-QE14 QH7-QH9 = DMN66D0LDW-7_SOT363-6
PQ220 PQ224 QA6 QA9 = SSM3K7002FU_SC70-3
PQ302 = L2N7002WT1G_SC70-3
PQ303 = SIR472DP-T1-GE3_POWERPAK8-5
PQ304 = SI7716ADN-T1-GE3_POWERPAK8-5
PQ305 = SI4835DDY-T1-E3_SO8
PQ1302 = AON7934_DFN3X3A8-10
PR107 PR903 PR1528 PR1529 = R_0805
PR200 PR231 PR300 PR313 = R_1206_4P-D
PR303 PR304 PR309 PR311 PR314 PR315 PR318 PR319 PR326 PR503 PR510 PR606 PR607 PR609 PR709 PR801 PR806 PR900 PR906 PR1024 PR1025 PR1027 PR1029 PR1059 PR1066 PR1076 PR1080 PR1083 PR1103 PR1119 PR1125 PR1400 PR1401 PR1409-PR1411 PR1419-PR1421 PR1501 PR1509 PR1510 PR1512 PR1524 R104 R250 R251 R289 R1006 R1200 R1210 R1212 R1436-R1442 R1444 R1445 R2663-R2665 RA26 RA30 RA31 RA54 RA59 RA63-RA65 RC19 RC154 RC155 RC169 RC171 RC213 RC221 RC228 RC247 RC248 RC290 RC296-RC298 RC301 RC310 RE32 RE62 RE92 RE104 RE105 RE107 RE120 RZ76 = R0402_0OHM
PR306 PR321 PR501 PR507 PR1086 PR1101 PR1106 PR1114 = R_1206
PR308 PR324 PR500 PR505 PR602 PR702 PR703 PR803 PR1082 PR1091 PR1100 PR1102 PR1105 PR1111 PR1113 PR1116 PR1403 PR1416 PR1505 PR1516 R531 RA81 RA82 RC97 RT114 RT241 = R_0603
PR512 PR513 R1322 R1326 R1329 R1342 R1344 R1393 R2669 R2672 = R0805_0OHM
PR1130-PR1137 = R0402_0OHM-NPM
PRP100 RP5 RP6 RPE5 RPE7 = RP_0804_8P4R
PU200 = INA199A1DCKR_SC70-6
PU201 PU203 PU400 = LM393DMR2G_MICRO8
PU202 = RT9069-33GB_SOT23-5
PU300 = BQ24777RUYR_WQFN28_4X4
PU401 PU402 = M74VHC1GT00DFT2G_SC70-5
PU500 = SY8286BRAC_QFN20_3X3
PU501 = SY8286CRAC_QFN20_3X3
PU600 = SY8210AQVC_QFN19_4X3
PU700 = SYX196DQNC_QFN10_3X3
PU800 PU900 = TLV62150RGTR_QFN16_3X3
PU1000 = ISL95857HRTZ-T_TQFN40_5X5
PU1100-PU1102 = CSD97374CQ4M_SON8_3P5X4P5
PU1305 = ISL95808HRZ-TS2378_DFN8_2X2
PU1400 = TPS62134ARGT_QFN16_3X3
PU1401 = TPS62134BRGT_QFN16_3X3
PU1500 PU1501 = TPS62134CRGT_QFN16_3X3
Q40 Q41 Q71 QT19 = L2N7002WT1G_SC-70-3
Q70 = SI3457BDV-T1-E3_TSOP6
Q72 QZ9 = DMG2301U-7_SOT23-3
QE3 QE4 QE8 QE10 QE11 = MMBT3904WT1G_SC70-3
R9 R10 R60 R1403 R1405 R1457-R1459 R1461 R1463-R1465 R1471 RC51 RE87 RE88 RH126 RT3 RT4 RT6-RT9 RT11 RT12 RT15-RT18 RT21-RT23 RT25 RT26 RT33-RT40 RT43-RT45 RT47-RT52 RT119-RT121 RT164 RT187 RT188 = R_0201
R1125 R1318 R1320 R1323 R1325 R1327 R1333-R1335 R1343 R2670 R2671 RA80 RC143 RC170 RC211 RC214 RC216 RC232 RC299 RC304 RC309 RH357 = R0603_0OHM
SW1 = SW_SSAL120100_3P
SW2 = SW_SKRBAAE010_4P
SW3 = SW_NTC311-EA1T-A160T_4P
T1 T2 T7-T19 T21 T113-T116 T121-T130 T183-T185 T187-T189 T192-T197 TC25 TC29 TC35 TC36 TC38 = TPC12
U15 = NPCT650JAAYX_QFN32_5X5
U18 = W25Q256FVEIG_WSON8
U48 = PCA9515BDGKR_VSSOP8
U664 U716 U717 U719 U720 = TPS22966DPUR_SON14_2X3
U683 = NL17SZ14DFT2G_SOT353-5
U699 = MC74VHC1G32DFT2G_SC70-5
U722 = TPS65982_BGA_96P
U728 = G9091-330TO1U_TSOT-23-5
U729 = MC74VHC1G09DFT2G_SC70-5
UA2 = ALC3246-CG_MQFN48_6X6
UC2 = 74AUP1G07GW_TSSOP5
UC7-UC11 UC13 = TC7SH08FU_SSOP5
UC12 = 74AHC1G09GW_TSSOP5
UCPU1 = SKL-U_BGA_1356P-T
UD19-UD22 = H9CCNNN8JTMLAR-NTM_FBGA_178P
UE4 = MCP23017T-E-ML_QFN28_6X6
UE5 = MEC5085-LZY_DQFN132_11X11
US2 = G547I1P81U_MSOP8
UT1 = AR-4C_BGA_337P-T
UT5 = W25Q80DVZPIG_WSON8
UT6 = W25Q64FVZPIG_WSON8_6X5
UZ19 UZ22 UZ23 UZ25 UZ26 = TPS22961DNYR_WSON8
UZ24 = SY6288C20AAC_SOT23-5
YC1 = Y_X3G024000DC1H_4P
YC2 = Y_9H03220008_2P
YE1 = Y_Q13FC135000040_2P
YT1 = Y_7V25000014_4P

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
74AHC1G09GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
74AUP1G07GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
ACES_50207-00471-P01_4P-T
  oval 0.508x0.991 smd: 1(0,0) 2(-0.8,0) 3(-1.6,0) 4(-2.4,0)
  rect 1.194x1.702 smd: 5(-3.7,1.45) 6(1.3,1.45)
ACES_50224-00401-001_4P
  oval 0.61x1.549 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0)
  rect 1.194x1.803 smd: 5(4.3,-3.875) 6(-1.3,-3.875)
ACES_50278-00201-001_2P
  oval 0.787x1.905 smd: 1(0,0) 2(1.25,0)
  rect 1.295x3.353 smd: 3(-2.85,-4.925) 4(4.1,-4.925)
ACES_50398-04041-001_40P
  oval 0.254x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0) 21(10,0) 22(10.5,0) 23(11,0) 24(11.5,0) 25(12,0) 26(12.5,0) 27(13,0) 28(13.5,0) 29(14,0) 30(14.5,0) 31(15,0) 32(15.5,0) 33(16,0) 34(16.5,0) 35(17,0) 36(17.5,0) 37(18,0) 38(18.5,0) 39(19,0) 40(19.5,0)
  rect 1.194x3.2 smd: 41(-2.4,1.95) 45(21.9,1.95)
  rect 2.311x1.295 smd: 42(0.85,3.9) 43(9.75,3.9) 44(18.65,3.9)
ACES_50506-00841-P01_8P
  oval 0.305x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0)
  rect 0.991x2.007 smd: 9(-2.1,-3.05) 10(5.6,-3.05)
ACES_50506-01841-P01_18P
  oval 0.305x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0)
  rect 0.991x2.007 smd: 19(-2.1,-3.05) 20(10.6,-3.05)
ACES_50696-0200M-P01_20P
  oval 0.305x0.787 smd: 1(0,0) 2(-0.5,0) 3(-1,0) 4(-1.5,0) 5(-2,0) 6(-2.5,0) 7(-3,0) 8(-3.5,0) 9(-4,0) 10(-4.5,0) 11(-5,0) 12(-5.5,0) 13(-6,0) 14(-6.5,0) 15(-7,0) 16(-7.5,0) 17(-8,0) 18(-8.5,0) 19(-9,0) 20(-9.5,0)
  rect 0.406x0.787 smd: 21(1,-2.5) 22(-10.5,-2.5)
ACES_88266-05001_5P
  oval 0.787x2.007 smd: 1(0,0) 2(1.25,0) 3(2.5,0) 4(3.75,0) 5(5,0)
  rect 2.007x2.489 smd: 6(7.2,-4.05) 7(-2.2,-4.05)
ALC3246-CG_MQFN48_6X6
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 25(6.1,-4.4) 26(6.1,-4) 27(6.1,-3.6) 28(6.1,-3.2) 29(6.1,-2.8) 30(6.1,-2.4) 31(6.1,-2) 32(6.1,-1.6) 33(6.1,-1.2) 34(6.1,-0.8) 35(6.1,-0.4) 36(6.1,0)
  oval 0.203x0.889 smd: 13(0.85,-5.25) 14(1.25,-5.25) 15(1.65,-5.25) 16(2.05,-5.25) 17(2.45,-5.25) 18(2.85,-5.25) 19(3.25,-5.25) 20(3.65,-5.25) 21(4.05,-5.25) 22(4.45,-5.25) 23(4.85,-5.25) 24(5.25,-5.25) 37(5.25,0.85) 38(4.85,0.85) 39(4.45,0.85) 40(4.05,0.85) 41(3.65,0.85) 42(3.25,0.85) 43(2.85,0.85) 44(2.45,0.85) 45(2.05,0.85) 46(1.65,0.85) 47(1.25,0.85) 48(0.85,0.85)
  rect 4.394x4.394 smd: 49(3.05,-2.2)
AON2405_DFN6-8
  oval 0.305x0.33 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.725) 5(0.65,1.725) 6(0,1.725)
  rect 0.94x0.991 smd: 7(0.325,0.863)
  rect 0.229x0.813 smd: 8(1.315,0.902)
AON7934_DFN3X3A8-10
  oval 0.457x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,2.76) 6(1.3,2.76) 7(0.65,2.76) 8(0,2.76)
  rect 2.54x1.041 smd: 9(0.975,1.813)
  rect 2.54x0.559 smd: 10(0.975,0.708)
AR-4C_BGA_337P-T
  round 0.254 smd: A1(0,0) A23(-10.12,0) AA2(-0.46,9.2) AA22(-9.66,9.2) AB2(-0.46,9.66) AB3(-0.92,9.66) AB4(-1.38,9.66) AB5(-1.84,9.66) AB6(-2.3,9.66) AB7(-2.76,9.66) AB8(-3.22,9.66) AB9(-3.68,9.66) AB10(-4.14,9.66) AB11(-4.6,9.66) AB12(-5.06,9.66) AB13(-5.52,9.66) AB14(-5.98,9.66) AB15(-6.44,9.66) AB16(-6.9,9.66) AB17(-7.36,9.66) AB18(-7.82,9.66) AB19(-8.28,9.66) AB20(-8.74,9.66) AB21(-9.2,9.66) AB22(-9.66,9.66) AC1(0,10.12) AC23(-10.12,10.12) B2(-0.46,0.46) B3(-0.92,0.46) B4(-1.38,0.46) B5(-1.84,0.46) B6(-2.3,0.46) B7(-2.76,0.46) B8(-3.22,0.46) B9(-3.68,0.46) B10(-4.14,0.46) B11(-4.6,0.46) B12(-5.06,0.46) B13(-5.52,0.46) B14(-5.98,0.46) B15(-6.44,0.46) B16(-6.9,0.46) B17(-7.36,0.46) B18(-7.82,0.46) B19(-8.28,0.46) B20(-8.74,0.46) B21(-9.2,0.46) B22(-9.66,0.46) C2(-0.46,0.92) C22(-9.66,0.92) D2(-0.46,1.38) D4(-1.16,1.16) D5(-1.81,1.16) D6(-2.46,1.16) D8(-3.11,1.16) D9(-3.76,1.16) D11(-4.41,1.16) D12(-5.06,1.16) D13(-5.71,1.16) D15(-6.36,1.16) D16(-7.01,1.16) D18(-7.66,1.16) D19(-8.31,1.16) D20(-8.96,1.16) D22(-9.66,1.38) E2(-0.46,1.84) E4(-1.16,1.81) E5(-1.81,1.81) E6(-2.46,1.81) E8(-3.11,1.81) E9(-3.76,1.81) E11(-4.41,1.81) E12(-5.06,1.81) E13(-5.71,1.81) E15(-6.36,1.81) E16(-7.01,1.81) E18(-7.66,1.81) E19(-8.31,1.81) E20(-8.96,1.81) E22(-9.66,1.84) F2(-0.46,2.3) F4(-1.16,2.46) F5(-1.81,2.46) F6(-2.46,2.46) F8(-3.11,2.46) F9(-3.76,2.46) F11(-4.41,2.46) F12(-5.06,2.46) F13(-5.71,2.46) F15(-6.36,2.46) F16(-7.01,2.46) F18(-7.66,2.46) F19(-8.31,2.46) F20(-8.96,2.46) F22(-9.66,2.3) G2(-0.46,2.76) G22(-9.66,2.76) H2(-0.46,3.22) H4(-1.16,3.11) H5(-1.81,3.11) H6(-2.46,3.11) H8(-3.11,3.11) H9(-3.76,3.11) H11(-4.41,3.11) H12(-5.06,3.11) H13(-5.71,3.11) H15(-6.36,3.11) H16(-7.01,3.11) H18(-7.66,3.11) H19(-8.31,3.11) H20(-8.96,3.11) H22(-9.66,3.22) J2(-0.46,3.68) J4(-1.16,3.76) J5(-1.81,3.76) J6(-2.46,3.76) J8(-3.11,3.76) J9(-3.76,3.76) J11(-4.41,3.76) J12(-5.06,3.76) J13(-5.71,3.76) J15(-6.36,3.76) J16(-7.01,3.76) J18(-7.66,3.76) J19(-8.31,3.76) J20(-8.96,3.76) J22(-9.66,3.68) K2(-0.46,4.14) K22(-9.66,4.14) L2(-0.46,4.6) L4(-1.16,4.41) L5(-1.81,4.41) L6(-2.46,4.41) L8(-3.11,4.41) L9(-3.76,4.41) L11(-4.41,4.41) L12(-5.06,4.41) L13(-5.71,4.41) L15(-6.36,4.41) L16(-7.01,4.41) L18(-7.66,4.41) L19(-8.31,4.41) L20(-8.96,4.41) L22(-9.66,4.6) M2(-0.46,5.06) M4(-1.16,5.06) M5(-1.81,5.06) M6(-2.46,5.06) M8(-3.11,5.06) M9(-3.76,5.06) M11(-4.41,5.06) M12(-5.06,5.06) M13(-5.71,5.06) M15(-6.36,5.06) M16(-7.01,5.06) M18(-7.66,5.06) M19(-8.31,5.06) M20(-8.96,5.06) M22(-9.66,5.06) N2(-0.46,5.52) N4(-1.16,5.71) N5(-1.81,5.71) N6(-2.46,5.71) N8(-3.11,5.71) N9(-3.76,5.71) N11(-4.41,5.71) N12(-5.06,5.71) N13(-5.71,5.71) N15(-6.36,5.71) N16(-7.01,5.71) N18(-7.66,5.71) N19(-8.31,5.71) N20(-8.96,5.71) N22(-9.66,5.52) P2(-0.46,5.98) P22(-9.66,5.98) R2(-0.46,6.44) R4(-1.16,6.36) R5(-1.81,6.36) R6(-2.46,6.36) R8(-3.11,6.36) R9(-3.76,6.36) R11(-4.41,6.36) R12(-5.06,6.36) R13(-5.71,6.36) R15(-6.36,6.36) R16(-7.01,6.36) R18(-7.66,6.36) R19(-8.31,6.36) R20(-8.96,6.36) R22(-9.66,6.44) T2(-0.46,6.9) T4(-1.16,7.01) T5(-1.81,7.01) T6(-2.46,7.01) T8(-3.11,7.01) T9(-3.76,7.01) T11(-4.41,7.01) T12(-5.06,7.01) T13(-5.71,7.01) T15(-6.36,7.01) T16(-7.01,7.01) T18(-7.66,7.01) T19(-8.31,7.01) T20(-8.96,7.01) T22(-9.66,6.9) U2(-0.46,7.36) U22(-9.66,7.36) V2(-0.46,7.82) V4(-1.16,7.66) V5(-1.81,7.66) V6(-2.46,7.66) V8(-3.11,7.66) V9(-3.76,7.66) V11(-4.41,7.66) V12(-5.06,7.66) V13(-5.71,7.66) V15(-6.36,7.66) V16(-7.01,7.66) V18(-7.66,7.66) V19(-8.31,7.66) V20(-8.96,7.66) V22(-9.66,7.82) W2(-0.46,8.28) W4(-1.16,8.31) W5(-1.81,8.31) W6(-2.46,8.31) W8(-3.11,8.31) W9(-3.76,8.31) W11(-4.41,8.31) W12(-5.06,8.31) W13(-5.71,8.31) W15(-6.36,8.31) W16(-7.01,8.31) W18(-7.66,8.31) W19(-8.31,8.31) W20(-8.96,8.31) W22(-9.66,8.28) Y2(-0.46,8.74) Y4(-1.16,8.96) Y5(-1.81,8.96) Y6(-2.46,8.96) Y8(-3.11,8.96) Y9(-3.76,8.96) Y11(-4.41,8.96) Y12(-5.06,8.96) Y13(-5.71,8.96) Y15(-6.36,8.96) Y16(-7.01,8.96) Y18(-7.66,8.96) Y19(-8.31,8.96) Y20(-8.96,8.96) Y22(-9.66,8.74)
  oval 0.178x0.33 smd: A2(-0.46,0) A3(-0.92,0) A4(-1.38,0) A5(-1.84,0) A6(-2.3,0) A7(-2.76,0) A8(-3.22,0) A9(-3.68,0) A10(-4.14,0) A11(-4.6,0) A12(-5.06,0) A13(-5.52,0) A14(-5.98,0) A15(-6.44,0) A16(-6.9,0) A17(-7.36,0) A18(-7.82,0) A19(-8.28,0) A20(-8.74,0) A21(-9.2,0) A22(-9.66,0) AC2(-0.46,10.12) AC3(-0.92,10.12) AC4(-1.38,10.12) AC5(-1.84,10.12) AC6(-2.3,10.12) AC7(-2.76,10.12) AC8(-3.22,10.12) AC9(-3.68,10.12) AC10(-4.14,10.12) AC11(-4.6,10.12) AC12(-5.06,10.12) AC13(-5.52,10.12) AC14(-5.98,10.12) AC15(-6.44,10.12) AC16(-6.9,10.12) AC17(-7.36,10.12) AC18(-7.82,10.12) AC19(-8.28,10.12) AC20(-8.74,10.12) AC21(-9.2,10.12) AC22(-9.66,10.12)
  oval 0.33x0.178 smd: AA1(0,9.2) AA23(-10.12,9.2) AB1(0,9.66) AB23(-10.12,9.66) B1(0,0.46) B23(-10.12,0.46) C1(0,0.92) C23(-10.12,0.92) D1(0,1.38) D23(-10.12,1.38) E1(0,1.84) E23(-10.12,1.84) F1(0,2.3) F23(-10.12,2.3) G1(0,2.76) G23(-10.12,2.76) H1(0,3.22) H23(-10.12,3.22) J1(0,3.68) J23(-10.12,3.68) K1(0,4.14) K23(-10.12,4.14) L1(0,4.6) L23(-10.12,4.6) M1(0,5.06) M23(-10.12,5.06) N1(0,5.52) N23(-10.12,5.52) P1(0,5.98) P23(-10.12,5.98) R1(0,6.44) R23(-10.12,6.44) T1(0,6.9) T23(-10.12,6.9) U1(0,7.36) U23(-10.12,7.36) V1(0,7.82) V23(-10.12,7.82) W1(0,8.28) W23(-10.12,8.28) Y1(0,8.74) Y23(-10.12,8.74)
