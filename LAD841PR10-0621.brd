# Allegro board LAD841PR10-0621.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TBT_ROM_CS#: length 29.9
  TOP w0.076: UT1.AC3 47.75,56.38 48.08,56.04 48.08,55.58 48.42,55.24 v2(48.58,55.24)
  TOP w0.127: UT5.1 49.15,36.94 v3(48.69,36.48) ; UT5.1 RT18.2 ; UT5.1 49.15,38.36 48.39,39.12 48.39,40.04 v2(48.57,40.22)
  IN2 w0.089: v2(48.57,40.22) 48.79,40.22 49.05,39.96 49.05,39.63 48.87,39.46 48.49,39.46 48.08,39.86 48.08,41.54 47.29,42.33 47.29,43.74 47,44.03 47,48.06 49.55,50.6 49.55,52.61 48.47,53.69 47.87,53.69 46.94,54.62 46.94,55.27 47.13,55.46 48.2,55.46 48.42,55.24 v2(48.58,55.24)
TBT_ROM_DI: length 22.3
  TOP w0.076: v2(48.03,54.97) 47.86,55.15 47.86,56.01 47.72,56.15 47.33,56.15 UT1.AB3
  TOP w0.127: v2(47.8,44.1) 47.14,44.1 47.06,44.18 45.64,44.18 43.58,42.12 UT5.5 42.88,42.12 v3(41.75,41)
  IN2 w0.089: v2(47.8,44.1) 47.9,44.2 47.9,45.17 47.31,45.77 47.31,48.05 49.77,50.51 49.77,52.7 48.13,54.33 48.13,54.87 v2(48.03,54.97)
TBT_ROM_DO: length 27.5
  TOP w0.127: v2(49.63,40.19) 49.15,39.71 UT5.2 49.53,39.2 RT16.2 ; UT1.AC4 47.68,56.84 47.73,56.79 48.24,56.79 v2(48.63,56.4)
  IN2 w0.089: v2(49.63,40.19) 49.47,40.19 49.26,39.99 49.26,39.54 48.96,39.24 48.4,39.24 47.87,39.77 47.87,41.45 47.07,42.24 47.07,43.65 46.79,43.94 46.79,48.29 48.67,50.17 48.67,52.36 48.17,52.86 47.56,52.86 46.9,53.52 46.9,54.36 46.72,54.53 46.72,55.6 47.53,56.4 v2(48.63,56.4)
  BOTTOM w0.127: v2(48.63,56.4) 48.03,56.4 v3(48.01,56.42)
TBT_ROM_HOLD#: length 5.5
  TOP w0.127: v3(42.83,36.53) 42.83,36.6 44.03,37.8 44.03,39.02 43.46,39.58 UT5.7 42.02,39.58 RT15.2
TBT_ROM_WP#: length 22.9
  TOP w0.127: v2(45.19,54.87) 45.26,54.95 UT1.V1 ; UT5.3 49.67,40.85 50.18,40.34 RT17.2 50.74,40.79 50.64,40.89 v3(50.64,41.36) 50.64,42.34 50.17,42.81 v2(46.58,42.81)
  IN2 w0.089: v2(45.19,54.87) 45.77,54.87 46.46,54.18 46.46,53.34 47.29,52.51 47.29,51.83 47.65,51.47 47.65,49.77 46.13,48.24 46.13,43.4 46.58,42.94 v2(46.58,42.81)
TBT_RSENSE: length 10.4
  TOP w0.127: v2(43.35,52.08) 43.66,51.77 RT10.2 ; v2(40.87,58.25) 40.87,58.25 UT1.J6
  BOTTOM w0.127: v2(40.87,58.25) 41.31,57.81 41.31,57.39 41.11,57.18 41.11,56.73 41.31,56.52 41.31,56.13 41.04,55.85 40.77,55.85 40.15,55.23 40.15,54.11 40.73,53.54 41.7,53.54 43.16,52.08 v2(43.35,52.08)
TBT_SBU1: length 12.9
  TOP w0.127: R1457.2 17.98,58.63 17.32,57.98 v3(17.15,57.98) 16.79,57.62 15.17,57.62 15.02,57.76 14.36,57.76 13.99,57.39 12.9,57.39 12.28,58.01 12.28,58.59 11.21,59.67 10.04,59.67 9.82,59.44 9.18,59.44 D78.1 8.29,59.74 7.99,60.04 JUSBC1.A8
TBT_SBU2: length 30.8
  TOP w0.127: R1458.2 17.43,58.94 v2(17.43,58.7) ; D87.1 14.07,66.57 14.35,66.85 v2(14.68,66.85) v1(15.16,67.33)
  IN1 w0.081: v2(17.43,58.7) 17.43,58.3 16.65,57.52 15.98,57.52 15.72,57.78 15.72,63.12 14.88,63.95 14.88,66.65 v2(14.68,66.85) 14.15,66.85 12.87,65.57 8.37,65.57 7.76,66.18 4.61,66.18 4.13,65.71 4.13,62.88 JUSBC1.B8
TBT_SLP_S3#: length 3.7
  TOP w0.076: RT119.2 38.46,53.81 38.74,54.09 38.74,54.99 39.04,55.29 39.04,55.7 UT1.D2
  TOP w0.127: v1(37.53,53.46) RT119.2
TBT_SRC_CFG1: length 3.3
  TOP w0.127: R1403.1 48.34,53.46 47.82,53.98 47.48,53.98 46.64,54.82 UT1.AA1
TBT_SRC_HPD: length 2.4
  TOP w0.127: UT1.G1 40.36,55.3 40.36,54.8 v1(40.85,54.31) 40.85,54.31 40.85,54.03 41.15,53.73 R1405.1
TBT_SVR_IND:
  vias: v3(35.79,53.92)
TBT_TEST_EN: length 2.1
  TOP w0.127: RT3.2 39.04,53.47 39.04,54.77 39.28,55.02 39.28,55.46 UT1.E1
TBT_TEST_PWRG: length 2.5
  TOP w0.076: 47.78,57.06 47.34,57.06 UT1.AB5
  TOP w0.127: 47.78,57.06 47.83,57.01 48.91,57.01 49.31,56.6 RT4.2
TBT_TMU_CLK_OUT: length 2.9
  TOP w0.076: 45.57,54.71 45.57,55.1 45.49,55.18 45.49,55.69 UT1.V2
  TOP w0.127: RT37.2 45.02,53.55 v1(45.02,54.33) 45.14,54.45 45.31,54.45 45.57,54.71
TBT_USB2_D_N: length 39.2
  TOP w0.076: U722.K5 21.35,62.63 21.25,62.73 20.88,62.73 20.76,62.85 19.32,62.85 19.3,62.88 19.28,62.88
  TOP w0.127: v2(16.72,67.02) 16.79,67.09 16.79,67.25 16.65,67.38 16.4,67.38 14.85,65.83 14.85,64.19 16.73,62.31 18.35,62.31 18.92,62.88 19.28,62.88 ; v2(38.93,64.11) 38.61,64.42 UT1.D20
  IN4 w0.091: v2(38.93,64.11) 38.99,64.11 39.19,64.31 39.19,64.48 38.28,65.39 38.28,66.33 37.04,67.56 24.71,67.56 23.25,69.03 19.08,69.03 17.48,67.43 16.88,67.43 16.72,67.27 v2(16.72,67.02)
TBT_USB2_D_P: length 39.2
  TOP w0.076: U722.L5 20.96,62.52 20.8,62.52 20.67,62.65 19.32,62.65 19.3,62.62 19.28,62.62
  TOP w0.127: 19.28,62.62 19.02,62.62 18.45,62.05 16.63,62.05 14.59,64.09 14.59,65.94 16.29,67.64 16.56,67.64 v2(16.72,67.8) ; v2(39.57,64.08) 39.25,64.4 UT1.E20
  IN4 w0.091: v2(39.57,64.08) 39.38,64.27 39.38,64.56 38.47,65.47 38.47,66.41 37.12,67.76 24.79,67.76 23.33,69.22 19,69.22 17.4,67.62 16.9,67.62 v2(16.72,67.8)
TBT_USB2_T_N: length 8.6
  TOP w0.076: U722.L6 19.77,61.97 19.55,61.75 v2(19.55,61.69)
  TOP w0.127: v2(16.44,58.65) 16.43,58.65 16.15,58.93 15.77,58.93 15.65,58.81 ML6.4
  IN1 w0.091: v2(16.44,58.65) 16.83,59.05 17.13,59.05 18.22,60.14 18.22,61.93 18.39,62.11 18.88,62.11 19.02,61.96 19.28,61.96 v2(19.55,61.69)
TBT_USB2_T_N_R: length 7.6
  TOP w0.127: ML6.3 13.64,58.58 13.34,58.87 13.11,58.87 D83.1 12.94,58.71 12.75,58.89 12.6,58.89 12.46,59.03 11.38,60.11 v4(10.53,60.11) 10.19,60.11 9.62,60.68 8.06,60.68 7.92,60.54 JUSBC1.A7
TBT_USB2_T_P: length 8.5
  TOP w0.076: v2(19.55,62.28) 19.65,62.18 20.79,62.18 20.84,62.23 21.25,62.23 21.33,62.16 U722.K6
  TOP w0.127: ML6.1 16.25,59.43 v2(16.44,59.24)
  IN1 w0.091: v2(16.44,59.24) 17.05,59.24 18.02,60.22 18.02,62.01 18.31,62.3 18.96,62.3 19.1,62.15 19.42,62.15 v2(19.55,62.28)
TBT_USB2_T_P_R: length 7.5
  TOP w0.127: JUSBC1.A6 7.95,61.04 8.06,60.94 9.72,60.94 10.3,60.36 11.49,60.36 v4(11.99,59.86) 12.64,59.21 12.8,59.21 12.94,59.35 D82.1 13.16,59.14 13.34,59.14 13.62,59.43 ML6.2
TBT_USB3_RX0_N: length 37
  TOP w0.076: v2(36.3,65.55) 36.23,65.48 36.23,65.06 36.42,64.87 37.07,64.87 37.28,64.66 UT1.A21
  BOTTOM w0.163: v2(36.3,65.55) 36.3,65.13 arc(36.37,64.97) 36.53,64.9 36.65,64.9 arc(36.77,64.92) 36.87,64.99 36.92,65.04 arc(36.97,65.13) 36.99,65.23 36.99,65.23 36.99,65.46 arc(36.97,65.6) 36.89,65.72 36.75,65.86 arc(36.6,65.96) 36.41,66 14.73,66 arc(14.29,65.91) 13.92,65.66 11.82,63.57 arc(11.4,63.27) 10.9,63.15 arc(10.86,63.14) 10.82,63.14 10.69,63.14 arc(10.59,63.12) 10.5,63.06 D85.1 10.01,62.95 arc(9.79,63.09) 9.54,63.14 7.21,63.14 arc(7,63.1) 6.82,62.98 6.67,62.83 arc(6.46,62.7) 6.22,62.65 5.8,62.65 arc(5.69,62.63) 5.59,62.56 JUSBC1.B10
TBT_USB3_RX0_P: length 37
  TOP w0.076: v2(36.31,64.48) 36.54,64.71 37,64.71 37.27,64.43 37.68,64.43 37.73,64.49 37.73,64.49 UT1.B21
  BOTTOM w0.163: v2(36.31,64.48) 36.35,64.52 arc(36.49,64.61) 36.65,64.65 arc(36.86,64.69) 37.05,64.81 37.09,64.86 37.09,64.86 arc(37.2,65.03) 37.24,65.23 37.24,65.46 arc(37.2,65.7) 37.06,65.9 36.93,66.03 arc(36.69,66.19) 36.41,66.25 14.73,66.25 arc(14.19,66.14) 13.74,65.84 11.64,63.74 arc(11.26,63.49) 10.8,63.4 D84.1 7.21,63.4 arc(6.9,63.33) 6.64,63.16 6.49,63.01 arc(6.37,62.93) 6.22,62.9 5.8,62.9 arc(5.72,62.91) 5.65,62.96 JUSBC1.B11
TBT_USB3_RX1_N: length 37.4
  TOP w0.076: v2(36.69,61.29) 36.51,61.48 36.51,61.58 36.59,61.67 37.67,61.67 UT1.B15
  TOP w0.163: JUSBC1.A10 8.18,59.04 8.3,58.92 8.4,58.92 arc(8.61,58.88) 8.78,58.76 9.51,58.03 arc(9.62,57.96) 9.74,57.93 9.9,57.93 arc(10,57.95) 10.08,58.01 D79.1 10.28,58.04 arc(10.4,57.96) 10.55,57.93 11.16,57.93 arc(11.22,57.94) 11.28,57.98 v2(11.5,58.2)
  BOTTOM w0.163: v2(36.69,61.29) 36.6,61.39 arc(36.53,61.48) 36.51,61.59 36.51,62.53 arc(36.43,62.91) 36.22,63.24 35.94,63.52 35.23,64.23 arc(34.97,64.4) 34.66,64.46 33.89,64.46 arc(33.58,64.4) 33.32,64.23 33.07,63.97 arc(32.89,63.71) 32.83,63.4 32.83,63.06 arc(32.79,62.85) 32.67,62.67 32.1,62.11 arc(31.93,61.99) 31.71,61.95 29.88,61.95 arc(29.36,61.73) 29.14,61.21 arc(29.12,61.06) 29.04,60.95 28.86,60.77 arc(28.68,60.65) 28.47,60.61 26.36,60.61 arc(26.25,60.63) 26.15,60.69 25.92,60.92 arc(25.66,61.1) 25.35,61.16 21.57,61.16 arc(21.35,61.11) 21.16,60.99 arc(21.04,60.91) 20.9,60.88 15.98,60.88 arc(15.32,60.75) 14.76,60.37 12.7,58.31 arc(12.42,58.12) 12.09,58.06 11.84,58.06 arc(11.65,58.1) v2(11.5,58.2)
TBT_USB3_RX1_P: length 37.4
  TOP w0.076: v2(35.87,61.29) 36.11,61.29 36.34,61.53 36.34,61.65 36.52,61.83 37.38,61.83 UT1.A15
  TOP w0.163: v2(11.5,57.41) 11.28,57.63 arc(11.22,57.67) 11.16,57.68 10.55,57.68 arc(10.4,57.65) 10.28,57.57 D80.1 10.04,57.64 arc(10,57.67) 9.95,57.68 9.74,57.68 arc(9.52,57.72) 9.34,57.85 8.63,58.55 8.6,58.58 arc(8.51,58.64) 8.4,58.66 8.3,58.66 8.18,58.54 JUSBC1.A11
  BOTTOM w0.163: v2(11.5,57.41) 11.5,57.54 arc(11.58,57.73) 11.76,57.81 12.09,57.81 arc(12.51,57.89) 12.87,58.13 14.94,60.19 arc(15.42,60.51) 15.98,60.63 20.9,60.63 arc(21.14,60.68) 21.34,60.81 arc(21.45,60.88) 21.57,60.91 25.35,60.91 arc(25.56,60.86) 25.75,60.74 25.82,60.67 25.97,60.52 arc(26.15,60.4) 26.36,60.36 28.47,60.36 arc(28.78,60.42) 29.04,60.59 29.21,60.77 arc(29.35,60.97) 29.39,61.21 arc(29.54,61.55) 29.88,61.69 31.71,61.69 arc(32.02,61.76) 32.28,61.93 32.85,62.49 arc(33.02,62.75) 33.08,63.06 33.08,63.4 arc(33.12,63.61) 33.24,63.79 33.5,64.05 arc(33.68,64.17) 33.89,64.21 34.66,64.21 arc(34.87,64.17) 35.05,64.05 36.04,63.06 arc(36.2,62.82) 36.26,62.53 36.26,61.66 arc(36.15,61.4) 35.89,61.29 v2(35.87,61.29)
TBT_USB3_TX0_N: length 29.8
  TOP w0.163: v2(31.47,63.56) 31.52,63.61 arc(31.6,63.73) 31.63,63.88 31.63,63.96 arc(31.75,64.25) 32.04,64.37 34.32,64.37 arc(34.46,64.4) CT40.2 ; JUSBC1.A3 7.82,62.54 7.95,62.66 8.23,62.66 8.88,63.32 arc(9.11,63.47) 9.37,63.52 10.49,63.52 arc(10.69,63.48) 10.86,63.37 D76.1 11,63.43 arc(11.1,63.5) 11.22,63.52 13.53,63.52 arc(13.78,63.42) v2(13.89,63.16)
  BOTTOM w0.163: v2(31.47,63.56) 31.62,63.71 arc(31.66,63.78) 31.68,63.85 31.68,63.96 arc(31.61,64.13) 31.45,64.19 17.31,64.19 arc(17.14,64.13) 17,64.03 16.85,63.87 arc(16.63,63.72) 16.37,63.67 14.13,63.67 arc(13.85,63.49) v2(13.89,63.16)
TBT_USB3_TX0_N_C: length 3.1
  TOP w0.076: 36.47,63.88 36.49,63.88 36.54,63.84 37.06,63.84 37.17,63.95 37.68,63.95 UT1.B19
  TOP w0.163: 36.47,63.88 36.26,63.88 35.93,64.22 35.41,64.22 CT40.1
TBT_USB3_TX0_P: length 29.8
  TOP w0.163: JUSBC1.A2 7.82,63.04 7.95,62.92 8.12,62.92 8.71,63.5 arc(9.01,63.7) 9.37,63.77 10.49,63.77 arc(10.69,63.81) 10.86,63.93 D75.1 11,63.87 arc(11.1,63.8) 11.22,63.77 13.54,63.77 arc(13.79,63.88) v2(13.89,64.12) ; v2(32.11,63.56) arc(31.95,63.63) 31.88,63.79 31.88,63.96 arc(31.93,64.07) 32.04,64.12 34.36,64.12 arc(34.59,63.98) CT39.2
  BOTTOM w0.163: v2(13.89,64.12) 14,64.02 arc(14.1,63.95) 14.23,63.92 16.37,63.92 arc(16.53,63.95) 16.66,64.04 16.83,64.2 arc(17.03,64.36) 17.28,64.45 31.45,64.45 arc(31.79,64.3) 31.93,63.96 31.93,63.85 arc(31.95,63.75) 32.01,63.66 v2(32.11,63.56)
TBT_USB3_TX0_P_C: length 3.2
  TOP w0.076: 36.47,63.63 36.49,63.63 36.54,63.68 36.97,63.68 37.15,63.49 37.54,63.49 37.63,63.58 37.63,63.67 37.56,63.74 UT1.A19
  TOP w0.163: 36.47,63.63 36.16,63.63 35.83,63.97 35.41,63.97 CT39.1
TBT_USB3_TX1_N: length 38.9
  TOP w0.163: v2(33.99,62.38) 34.08,62.47 arc(34.22,62.57) 34.39,62.6 34.54,62.6 arc(34.73,62.56) 34.89,62.46 CT38.2
  BOTTOM w0.163: v2(33.99,62.38) 34.18,62.57 arc(34.28,62.63) 34.4,62.66 arc(34.52,62.63) 34.62,62.57 34.71,62.47 arc(34.8,62.34) 34.83,62.18 34.83,61.91 arc(34.76,61.53) 34.55,61.21 33.65,60.32 arc(33.44,60.18) 33.19,60.13 32.68,60.13 arc(32.37,60.07) 32.11,59.89 31.18,58.96 arc(31.07,58.79) 31.03,58.6 31.03,58.47 arc(31.01,58.38) 30.95,58.29 30.54,57.88 arc(30.32,57.73) 30.06,57.68 27.78,57.68 arc(27.5,57.74) 27.27,57.89 25.57,59.59 arc(25.19,59.85) 24.74,59.94 16.04,59.94 arc(15.71,59.87) 15.43,59.68 14.75,59 arc(14.6,58.78) 14.55,58.52 14.55,58.38 arc(14.52,58.23) 14.43,58.09 12.76,56.43 arc(12.59,56.31) 12.38,56.27 11.54,56.27 arc(11.37,56.3) 11.23,56.4 11,56.63 arc(10.96,56.69) 10.95,56.77 10.95,57.33 arc(10.91,57.52) 10.79,57.68 arc(10.76,57.71) 10.72,57.73 10.42,57.92 arc(10.26,58.09) D89.1 arc(10.03,57.95) 9.65,57.8 9.54,57.8 arc(9.37,57.77) 9.22,57.68 arc(9.17,57.67) 9.12,57.66 7.95,57.66 arc(7.8,57.69) 7.68,57.77 6.94,58.52 arc(6.66,58.71) 6.33,58.77 5.94,58.77 arc(5.91,58.77) 5.87,58.78 arc(5.81,58.81) 5.76,58.85 JUSBC1.B3
TBT_USB3_TX1_N_C: length 2.7
  TOP w0.076: 36.26,62.58 36.29,62.58 36.33,62.62 36.53,62.62 36.66,62.75 37.11,62.75 37.26,62.59 37.68,62.59 37.9,62.82 UT1.B17
  TOP w0.163: 36.26,62.58 35.72,62.58 CT38.1
TBT_USB3_TX1_P: length 38.9
  TOP w0.163: CT37.2 34.9,62.98 arc(34.76,62.88) 34.59,62.85 34.23,62.85 arc(34.17,62.86) 34.12,62.9 v2(33.99,63.03)
  BOTTOM w0.163: v2(33.99,63.03) arc(34.12,62.94) 34.27,62.91 34.4,62.91 arc(34.61,62.87) 34.8,62.74 34.89,62.65 34.89,62.65 arc(35.03,62.44) 35.08,62.18 35.08,61.9 arc(34.99,61.43) 34.72,61.04 34.04,60.35 33.83,60.14 arc(33.54,59.95) 33.19,59.88 32.68,59.88 arc(32.47,59.83) 32.29,59.72 31.36,58.78 arc(31.3,58.7) 31.28,58.6 31.28,58.47 arc(31.24,58.28) 31.13,58.11 30.72,57.7 arc(30.42,57.5) 30.06,57.43 27.78,57.43 arc(27.4,57.5) 27.09,57.71 25.39,59.41 arc(25.09,59.61) 24.74,59.68 16.04,59.68 arc(15.8,59.64) 15.61,59.5 14.93,58.83 arc(14.83,58.68) 14.8,58.52 14.8,58.38 arc(14.75,58.13) 14.6,57.92 12.94,56.25 arc(12.68,56.08) 12.38,56.02 11.54,56.02 arc(11.28,56.07) 11.06,56.22 10.82,56.45 arc(10.73,56.59) 10.69,56.77 10.69,57.33 arc(10.63,57.49) 10.47,57.55 D88.1 9.54,57.55 arc(9.45,57.53) 9.37,57.48 arc(9.25,57.43) 9.12,57.41 7.95,57.41 arc(7.71,57.46) 7.51,57.59 6.83,58.27 6.76,58.34 arc(6.56,58.47) 6.33,58.52 5.74,58.52 arc(5.56,58.49) JUSBC1.B2
TBT_USB3_TX1_P_C: length 2.7
  TOP w0.076: 36.26,62.83 36.29,62.83 36.33,62.79 36.46,62.79 36.59,62.91 37.06,62.91 37.2,63.05 37.56,63.05 37.63,62.98 37.63,62.86 37.58,62.82 37.44,62.82 UT1.A17
  TOP w0.163: 36.26,62.83 35.73,62.83 CT37.1
TBT_USB_OC0#: length 177.2
  TOP w0.127: v2(18.62,61.7) 18.79,61.52 R1438.2
  IN3 w0.089: v2(148.44,74.41) 148.26,74.41 147.93,74.08 147.93,73.88 146.37,72.32 143.64,72.32 143.15,72.81 143.15,74.46 142.95,74.66 142.75,74.66 142.63,74.77 141.39,74.77 140.77,74.15 140.77,72.86 138.37,70.46 137.54,70.46 137.29,70.21 136.65,70.21 136.54,70.33 135.52,70.33 135.52,70.34 134.6,71.26 129.51,71.26 129.01,70.75 127.64,70.75 127.13,71.26 121.82,71.26 121.2,70.64 117.52,70.64 117.15,70.27 113.71,70.27 113.46,70.03 113.46,69.71 112.96,69.2 111.46,69.2 110.77,68.51 106.94,68.51 106.39,67.96 100.49,67.96 99.11,69.34 93.92,69.34 91.88,67.3 83.68,67.3 82.08,68.91 79.8,68.91 79.23,68.34 74.2,68.34 73.82,68.72 73.82,69.94 73.13,70.63 71.82,70.63 71.54,70.35 61.22,70.35 59.37,72.21 56.44,72.21 55.79,71.55 55.79,70.06 54.97,69.25 54.97,67.76 55.14,67.59 55.14,59.68 54.42,58.96 54.42,54.29 49.44,49.31 44.73,49.31 42.42,47 40.61,47 40.31,47.3 40.31,49.5 37.47,52.35 37.47,53.53 36.92,54.07 34.68,54.07 34.36,54.39 32.34,54.39 30.18,56.55 29.15,56.55 28.84,56.85 24.84,56.85 23.9,57.8 23.9,59.05 23.61,59.33 22.44,59.33 20.98,60.79 19.53,60.79 v2(18.62,61.7)
  BOTTOM w0.127: UCPU1.A9 147.47,72.6 147.83,72.96 147.83,75.09 RC189.1 v2(148.44,74.41)
TBT_VBUS: length 55.5
  TOP w0.254: JUSBC1.B9 6.17,62.04 JUSBC1.A4 ; JUSBC1.B4 6.17,59.54 JUSBC1.A9
  TOP w0.381: D123.1 v2(13.06,55.73) ; v2(60.48,72.42) 60.48,71.87 59.83,71.22 59.08,71.22 58.78,70.91 57.42,70.91 57.15,71.18 57.15,71.64 55.54,73.25 54.66,73.25 53.7,74.21 53.7,75.52 52.62,76.6 v2(52.62,76.98)
  TOP w0.508: v2(79.73,71.46) 80.06,71.79 80.06,73.16 80.98,74.08 PR264.1
  IN1 w0.508: v2(46.1,75.17) 51.19,75.17 52.62,76.6 v2(52.62,76.98)
  IN3 w0.508: v2(79.73,71.46) 78.15,73.04 65.37,73.04 64.65,72.32 60.58,72.32 v2(60.48,72.42)
  BOTTOM w0.381: CT9.1 9.86,56.18 v2(9.88,56.16) ; v2(8.41,58.15) 8.41,58.4 8.1,58.71 C398.2 C401.2
  BOTTOM w0.508: C402.2 C397.2 7.87,61.17 7.06,61.99 JUSBC1.B9
  vias: v2(18.24,56.45) v2(18.23,55.86) v2(18.72,54.9) v2(19.31,54.87) v2(19.92,54.83) v2(44.65,74.89) v2(44.93,75.42) v2(45.21,74.63) v2(45.49,75.78) v2(45.52,75.17) v2(45.97,74.58) v2(46.08,75.75) v3(45.47,74.1)
TBT_VBUS_L: length 4.4
  TOP w0.127: U722.J11 22.01,59.18 ; U722.J11 U722.H11 ; U722.J11 U722.J10 ; U722.J11 U722.K11 ; v3(21.45,54.02) 21.45,54.41 LT106.1
TCLK_XDP: length 78.2
  TOP w0.127: RC139.2 63.09,75.37 v2(62.97,75.24) 62.64,74.91 62.64,72.53 63.49,71.67 64.35,71.67 64.6,71.92 JXDP1.57 ; v3(117.96,74.41) 117.34,74.41 v2(116.61,75.13)
  IN3 w0.089: v2(118.13,76.26) 118.13,75.65 117.62,75.13 v2(116.61,75.13) 116.3,74.82 109.3,74.82 106.33,71.86 102.42,71.86 99.42,74.85 92.54,74.85 91.87,74.17 90.43,74.17 89.98,73.73 80.4,73.73 78.69,75.43 70.4,75.43 69.82,76.01 65.75,76.01 65.44,75.7 63.42,75.7 v2(62.97,75.24)
  BOTTOM w0.076: UCPU1.A59 118.77,72.4 118.77,74.41 118.13,75.04 v2(118.13,76.26) ; UCPU1.B61 117.52,71.87 117.52,72.09 117.46,72.21 117.46,72.47 117.56,72.57 117.56,74.36 116.79,75.13 v2(116.61,75.13)
  BOTTOM w0.127: RC87.1 118.13,76.59 v2(118.13,76.26)
TDI_XDP: length 79.3
  TOP w0.127: v2(65.15,69.22) 65.1,69.17 JXDP1.56 ; v2(118.58,75.86) 118.58,76.41 118.09,76.9 RC81.2 118.59,77.66 118.59,78.36 117.84,79.11 117.09,79.11 v3(116.92,79.28) 116.35,79.85 97.91,79.85 95.53,77.47 95.53,76.79 95.24,76.51 94.86,76.51 92.55,78.82 89.63,78.82 v2(89.33,78.52)
  IN1 w0.081: v2(71.27,79.59) 69.81,78.13 69.81,77.38 69,76.57 68.46,76.57 67.89,76.01 67.36,76.01 v2(66.57,75.22)
  IN3 w0.089: v2(71.27,79.59) 71.27,79.52 71.74,79.06 72.08,79.06 72.26,79.24 73.42,79.24 73.75,78.9 78.66,78.9 80.73,76.83 83.19,76.83 84.27,77.91 88.72,77.91 v2(89.33,78.52)
  IN4 w0.081: v2(66.57,75.22) 66.7,75.09 66.7,73.29 65.43,72.02 65.43,69.5 v2(65.15,69.22)
  BOTTOM w0.076: UCPU1.D59 119,70.51 119,70.61 119.1,70.78 119.15,70.96 119.15,71.07 119.18,71.18 119.28,71.5 119.29,71.55 119.29,71.8 119.25,71.89 119.25,72.08 119.29,72.18 119.29,72.54 119.13,72.69 119.13,75.19 118.58,75.74 v2(118.58,75.86)
  BOTTOM w0.127: RC134.2 89.95,77.89 v2(89.33,78.52) ; UCPU1.D59 118.53,70.69 UCPU1.D60
TDO_XDP: length 94.4
  TOP w0.127: v2(94.01,76.64) 92.69,77.95 v3(92.19,77.95) 88.9,77.95 v2(88.46,78.4) ; JXDP1.52 66.1,67.33 66.1,69.26 65.03,70.33 64.46,70.33 v2(63.81,70.98) ; v2(116.62,75.73) 117.53,74.82 118.98,74.82 119.76,75.6 v2(119.76,75.73) 120.23,75.73 120.38,75.58 121.24,75.58 121.64,75.98 121.64,77.83 RC82.2
  IN3 w0.089: v2(88.46,78.4) 88.19,78.13 84.18,78.13 83.1,77.05 80.82,77.05 78.75,79.12 74.58,79.12 v2(73.69,80)
  IN4 w0.081: v2(119.76,75.73) 119.78,75.75 119.78,76.74 117.68,78.85 110.34,78.85 110.17,79.02 108.88,79.02 108.76,78.91 95.43,78.91 94.01,77.48 v2(94.01,76.64)
  BOTTOM w0.076: v2(119.76,75.73) 119.63,75.6 119.63,74.32 120.31,73.65 120.31,72.41 UCPU1.A56 ; v2(116.62,75.73) 117.73,74.62 117.73,72.32 UCPU1.A61
  BOTTOM w0.127: RC135.2 89,77.85 v2(88.46,78.4) ; v2(63.81,70.98) 63.81,71.54 65,72.73 65,73.98 64.61,74.38 64.61,75.91 63.55,76.97 63.55,77.77 66.46,80.68 73.01,80.68 v2(73.69,80)
THERMATRIP2#: length 13.8
  TOP w0.127: QE9.1 175.39,69.26 175.39,70.31 175.11,70.59 175.11,71.5 174.82,71.78 174.82,72.7 175.46,73.34 v3(177.14,73.34) 177.9,73.34 178.72,72.52 178.72,71.69 RE69.2 CE61.1 177.98,68.89 178.61,68.26 178.61,67.87 UE5.B34
THERMATRIP3#: length 3.7
  TOP w0.127: UE5.A2 188.46,60.02 188.58,60.14 189,60.14 189.21,59.94 189.21,59.62 v3(189.43,59.39) 189.59,59.55 189.59,59.85 189.87,60.13 190.5,60.13 RE67.1
THERMDA: length 0.5
  TOP w0.127: UT1.AB23 UT1.AC23
THSEL_STRAP: length 16.9
  TOP w0.127: RE78.1 181.76,74.13 v2(181.99,74.36) 181.99,74.74 v3(181.23,75.5) ; v2(181.31,67.17) 181.31,67.22 181.11,67.41 UE5.B29
  BOTTOM w0.127: v2(181.31,67.17) 181.31,67.08 180.97,66.74 178.57,66.74 178.3,67.02 178.3,68.37 177.63,69.05 177.63,71.94 179.11,73.43 179.87,73.43 180.8,74.36 v2(181.99,74.36)
TMS_XDP: length 76.5
  TOP w0.127: v2(118.52,75.24) 117.74,76.02 117.39,76.02 116.82,76.59 RC130.2 v3(115.03,78.93) 114.37,79.6 98.15,79.6 97.13,78.58 97.13,76.81 97.3,76.65 97.3,76.22 97.06,75.98 94.06,75.98 93.27,76.77 92.25,76.77 91.91,76.44 v2(91.91,76.36) ; JXDP1.58 64.6,69.18 v2(64.56,69.22)
  IN4 w0.081: v2(91.91,76.36) 88.23,76.36 87,75.13 85.85,75.13 85.17,75.81 80.3,75.81 79.06,77.05 72.87,77.05 71.83,76.01 67.41,76.01 67.04,75.63 67.04,73.33 65.64,71.93 65.64,69.08 65.38,68.82 64.9,68.82 64.56,69.16 v2(64.56,69.22)
  BOTTOM w0.076: v2(118.52,75.24) 118.95,74.81 118.95,72.64 119.12,72.47 119.12,72.21 119.07,72.09 119.07,71.94 119.12,71.75 119.12,71.57 119.04,71.32 119,71.26 118.97,71.2 118.97,71.12 UCPU1.C59
  BOTTOM w0.127: v2(91.91,76.36) 91.91,76.62 91.16,77.38 RC131.2 ; UCPU1.C60 118.53,71.34 UCPU1.C59
TOUCH_SCREEN_PD#: length 100.6
  BOTTOM w0.127: UCPU1.A7 150,73.72 150.32,73.72 151.49,74.89 RC277.2 151.02,76.17 151.02,77.09 150.74,77.37 149.99,77.37 146.35,81.02 97.54,81.02 93.14,76.62 93.14,76.19 92.26,75.32 91.52,75.32 91.13,75.7 90.2,75.7 89.15,74.65 89.15,71.73 88.46,71.04 86.57,71.04 85.21,72.4 80.89,72.4 80.53,72.77 76.76,72.77 76.54,72.98 74.23,72.98 73.67,72.42 v3(73.08,72.42) 72.88,72.42 70.51,74.79 70.51,77.05 71.22,77.76 JTS.5
TOUCHPAD_INTR#: length 11.2
  BOTTOM w0.076: UCPU1.BA5 149.52,50.31 149.86,49.97 149.86,49.53 150.22,49.17 150.53,49.17 150.71,48.99
  BOTTOM w0.127: v3(158.11,49.41) 157.79,49.09 157.79,48.3 DZ3.2 157.58,48.22 157.03,47.67 156.32,47.67 RC272.2 155.34,48.65 151.05,48.65 150.71,48.99
TP_PW_EN: length 148.2
  TOP w0.127: v3(167.41,14.76) 167.26,14.6 v2(167.26,14.18) 167.79,13.65 168.99,13.65 R1175.2 169.65,14.18 170.74,15.27 170.74,15.81 170.9,15.97 U716.3
  IN3 w0.089: v2(63.35,14.31) 62.97,13.93 61.21,13.93 59.64,15.5 56.26,15.5 55.96,15.81 50.4,15.81 48.78,14.19 40.03,14.19 39.39,14.82 35.36,14.82 v2(34.24,13.7)
  BOTTOM w0.127: UE4.24 34.59,14.05 v2(34.24,13.7) ; v2(167.26,14.18) 167.26,13.84 166.58,13.16 135.06,13.16 130.76,17.46 127.46,17.46 125.22,15.22 114.37,15.22 111.95,17.64 107.15,17.64 105.79,16.29 95.57,16.29 94.41,15.14 64.18,15.14 v2(63.35,14.31)
TPM_DET: length 6.3
  TOP w0.127: v2(145.38,54.38) 145.77,54.78 145.77,55.79 146.43,56.45 146.43,56.87 146.63,57.08 147.4,57.08 RH153.1 RH148.2
  BOTTOM w0.127: v2(145.38,54.38) 145.33,54.38 144.97,54.75 UCPU1.AP13
TPM_LPM#: length 18.7
  TOP w0.127: R1006.1 183.15,50.21 183.73,50.79 185.03,50.79 185.42,51.17 185.94,51.17 186.33,50.79 186.51,50.79 186.85,50.45 186.85,50.07 187.1,49.82 187.76,49.82 188.61,48.97 v3(188.88,48.97) 188.98,48.87 192,48.87 192.19,49.05 195.02,49.05 RE91.1 196.29,47.79 196.8,47.79 198.16,46.43 Q72.1
TPM_PIRQ#: length 75.6
  TOP w0.127: U15.18 188.52,44.08 188.81,43.78 190.06,43.78 RH126.2 190.31,43.07 188.79,41.55 188.79,40.46 187.92,39.59 186.62,39.59 185.82,38.79 v3(185.37,38.79) 182.67,38.79 180.78,40.69 180.78,41.08 180.23,41.63 v2(179.74,41.63)
  IN2 w0.089: v2(153.65,66.51) 154.19,66.51 155.6,65.1 155.6,64.51 155.19,64.1 155,64.1 154.48,63.58 154.48,62.88 154.89,62.47 156.72,62.47 157.98,61.21 163.7,61.21 165.23,59.69 170.68,59.69 171.52,58.84 172.18,58.84 172.37,59.04 173.29,59.04 175.31,57.01 175.31,53.2 175.12,53.01 175.12,51.79 175.62,51.3 177.43,51.3 180.04,53.9 180.85,53.9 181.83,52.93 181.83,43.15 180.31,41.63 v2(179.74,41.63)
  BOTTOM w0.076: v2(153.65,66.51) 153.57,66.43 151.1,66.43 UCPU1.M3
TRST#_XDP: length 84.3
  TOP w0.127: v2(117.37,75.59) 116.82,76.14 116.36,76.14 115.94,75.72 v3(115.94,74.6) 114.72,74.6 113.82,73.69 110.97,73.69 110.72,73.94 109.79,73.94 109.45,74.28 109.45,75.04 109.12,75.37 108.59,75.37 108.19,75.77 108.19,76.37 107.49,77.07 107.49,77.49 106.02,78.96 102.05,78.96 99.01,75.92 97.9,75.92 97.33,75.35 95.41,75.35 93.7,73.63 93.7,72.46 93.03,71.78 93.03,71.44 92.68,71.1 88.88,71.1 v2(88.32,71.66) ; JXDP1.54 65.6,66.26 65.87,65.99 66.43,65.99 66.9,65.52 v2(66.9,65.39) ; v2(79.86,66.76) 79.86,70.57 80.54,71.26 80.54,72.75 v2(80.9,73.11)
  IN4 w0.081: v2(79.86,66.76) 79.17,66.07 67.59,66.07 v2(66.9,65.39)
  BOTTOM w0.076: UCPU1.B59 118.59,71.93 118.59,74.24 117.6,75.23 117.6,75.36 v2(117.37,75.59) 116.87,76.09 116.45,76.09 116.21,75.84 116.21,75.02 116.44,74.78 116.87,74.78 117.39,74.25 117.39,72.63 117.3,72.54 117.3,72.17 117.31,72.14 117.33,72.08 117.33,71.41 UCPU1.C61
  BOTTOM w0.127: v2(88.32,71.66) 87.95,71.29 86.68,71.29 85.31,72.66 81.35,72.66 v2(80.9,73.11) 80.81,73.02 79.05,73.02 RC136.2
UART0_TX: length 34
  BOTTOM w0.127: JDEG1.9 173.65,68.67 173.41,68.91 172.69,68.91 171.31,70.29 169.8,70.29 168.34,68.82 167.51,68.82 166.18,70.15 165.58,70.15 165.42,70.32 164.71,70.32 164.32,69.93 161.96,69.93 161.61,69.57 161.61,67.18 162.63,66.15 162.63,65.23 162.2,64.8 162.2,62.99 160.49,61.27 158.67,61.27 158.5,61.1 v3(157.89,61.1) 157.43,61.1 156.9,60.57 154.65,60.57 154.23,60.99 152.42,60.99 152.27,61.15 151.77,61.15 UCPU1.AB2
UART1_RXD: length 175.7
  IN1 w0.081: v2(165.86,39.69) 165.85,39.69 165.81,39.66 165.84,39.63 165.84,37.91 165.1,37.17 165.1,34.25 164.95,34.1 164.95,27 163.26,25.31 163.26,23.06 160.72,20.52 158.05,20.52 156.69,19.16 146.41,19.16 145.71,18.46 133.69,18.46 132.6,19.55 126.13,19.55 125.56,18.99 118.29,18.99 117.49,19.8 112.59,19.8 110.54,21.84 103.19,21.84 102.93,21.58 97.85,21.58 96.04,23.39 96.04,26.42 92,30.46 91.59,30.46 90.65,31.4 83.53,31.4 81.98,29.85 77.01,29.85 72.72,25.56 70.26,25.56 67.34,22.64 66.12,22.64 v2(66.09,22.61)
  IN4 w0.081: v2(154.89,59.24) 155.14,59.24 156.63,57.75 156.63,57.03 158.52,55.14 158.52,52.72 165.76,45.47 165.76,39.79 v2(165.86,39.69)
  BOTTOM w0.127: v2(66.09,22.61) 63.86,20.38 59.01,20.38 57.74,19.11 55.3,19.11 v3(54.4,20.01) 53.84,20.57 JUART.3 49.11,20.57 RH563.2 ; v2(154.89,59.24) 154.89,59.68 154.15,60.41 152.87,60.41 152.64,60.18 UCPU1.AC1
UART1_TXD: length 175.2
  IN1 w0.089: v2(57.81,24.93) 59.64,26.76 63.04,26.76 63.75,27.47 72.67,27.47 76.42,31.21 81.4,31.21 83.43,33.24 87.54,33.24 88.11,33.82 88.62,33.82 89.26,33.17 90.97,33.17 92.19,31.95 92.46,31.95 92.76,31.65 92.76,31.18 94.16,29.78 95.09,29.78 96.87,28 96.87,23.74 98.18,22.44 102.58,22.44 102.81,22.67 110.89,22.67 112.93,20.63 117.83,20.63 118.64,19.82 125.2,19.82 125.77,20.4 155.66,20.4 163.85,28.58 163.85,33.63 163.75,33.73 163.75,33.73 163.66,33.83 163.66,37.02 163.78,37.15 163.78,37.15 163.85,37.21 163.85,39.21 163.58,39.48 163.58,39.48 v2(162.94,40.12)
  IN4 w0.089: v2(162.94,40.12) 163.56,40.73 163.56,47.38 158.3,52.63 158.3,55.05 155.23,58.12 v2(154.89,58.12)
  BOTTOM w0.076: 153.17,59.99 152.07,59.99 151.95,59.93 151.68,59.93 151.56,60 151.32,60 UCPU1.AC2
  BOTTOM w0.127: v2(57.81,24.93) 57.4,24.52 56.06,24.52 55.66,24.92 51.15,24.92 50.07,23.84 v1(50.07,23.32) 50.07,22.37 RH562.2 49.99,21.24 50.11,21.37 JUART.2 ; v2(154.89,58.12) 154.51,58.51 154.51,59.52 154.04,59.99 153.17,59.99
UPD_EN1_4#: length 2.3
  TOP w0.127: UE5.B53 179.11,59.07 178.89,59.29 v2(178.87,59.29)
  BOTTOM w0.127: v2(178.87,59.29) 179.05,59.11 v3(179.05,58.76) RE107.2
UPD_MRESET: length 291.9
  TOP w0.127: v2(27.5,46.09) 27.5,45.69 v1(27.72,45.46) RE90.1 29.16,45.46 29.62,45.92 RT121.1 29.88,46.18 30.28,46.58 30.28,47.71 v2(30.61,48.04) ; R1465.2 22.04,54.76 v2(22.04,54.76) ; UE5.A4 188.34,61.02 188.63,60.73 189.03,60.73 189.61,61.3 189.98,61.3 190.4,61.73 192.34,61.73 193.08,60.98 v2(193.08,59.73)
  IN2 w0.089: v2(70.89,14.47) 70.42,14.94 65.49,14.94 64.97,15.46 54.77,15.46 54.17,16.06 51.62,16.06 50.72,15.16 43.27,15.16 42.74,14.62 39.91,14.62 39.52,15.01 39.52,15.13 38.33,16.33 37.73,16.33 32.99,21.06 32.99,21.99 34.14,23.14 34.14,25.19 33.57,25.76 33.57,31.28 34.55,32.25 34.55,38.76 34.08,39.23 34.08,40.98 34.56,41.46 34.56,42.03 33.71,42.88 33.37,42.88 31.98,44.27 31.98,46.67 v2(30.61,48.04)
  IN3 w0.089: v2(27.5,46.09) 26.97,46.09 25.54,47.52 25.54,50.15 22.04,53.65 v2(22.04,54.76)
  IN4 w0.081: v2(70.89,14.47) 72.04,15.62 95.09,15.62 95.57,16.1 99.51,16.1 99.99,15.62 131.76,15.62 134.01,13.37 200.38,13.37 202.53,15.53 203,15.53 204.37,16.9 210.08,16.9 210.58,17.41 210.58,17.98 209.99,18.58 208,18.58 206.46,20.12 206.46,20.39 202.47,24.38 202.47,32.84 198.6,36.71 198.6,41.28 196.97,42.91 196.97,46.96 198.22,48.21 198.22,49.26 194.97,52.52 194.97,55.2 192.65,57.52 192.65,59.24 193.08,59.68 v2(193.08,59.73)
UPD_SMBCLK: length 195.8
  TOP w0.076: U722.B5 25.33,62.29 v2(25.04,62.29)
  TOP w0.127: UE5.B49 178.01,60.27 178.87,60.27 v2(179.03,60.44)
  IN3 w0.089: v2(25.04,62.29) 25.1,62.34 26.77,62.34 27,62.11 27.73,62.11 28.05,62.44 28.05,67.38 28.6,67.93 28.6,70.47 30.51,72.37 34.95,72.37 38.24,75.66 42.93,75.66 45.7,72.89 50.74,72.89 58.33,80.48 77.7,80.48 80.91,77.27 83.01,77.27 84.57,78.83 86.97,78.83 87.37,79.23 89.84,79.23 90.84,80.23 151.7,80.23 152.46,79.47 155.13,79.47 155.72,80.06 172.02,80.06 178.03,74.04 178.54,74.04 179.05,74.55 v2(179.05,74.81)
  IN4 w0.089: v2(179.05,74.81) 178.12,73.88 178.12,73.07 176.71,71.67 176.71,69.21 176.96,68.96 176.96,67.24 177.7,66.5 177.7,63.53 178.59,62.64 179.74,62.64 179.98,62.4 179.98,61.95 179.09,61.07 179.09,60.5 v2(179.03,60.44)
  BOTTOM w0.127: RE88.1 CE71.1 178,60.96 178.52,60.44 v2(179.03,60.44)
UPD_SMBDAT: length 192.3
  TOP w0.127: v2(178.44,74.84) 178.44,73.82 v1(178.67,73.59) ; U722.A5 26.14,62.34 26.77,62.34 v2(27.06,62.63) ; v2(178.66,60.9) 178.53,60.77 UE5.B48
  IN3 w0.089: v2(27.06,62.63) 27.06,62.78 26.64,63.2 26.31,63.2 26.09,63.43 26.09,63.92 26.95,64.78 27.41,64.78 27.74,65.11 27.74,67.37 28.35,67.98 28.35,70.52 30.42,72.59 34.86,72.59 38.15,75.88 43.02,75.88 45.79,73.1 50.65,73.1 58.24,80.69 77.79,80.69 81,77.48 82.92,77.48 85.18,79.74 86.72,79.74 87.43,80.45 152.42,80.45 153.22,79.65 155.04,79.65 155.67,80.28 172.21,80.28 174.85,77.63 175.37,77.63 178.17,74.84 v2(178.44,74.84)
  IN4 w0.089: v2(178.44,74.84) 177.9,74.3 177.9,73.16 176.44,71.7 176.44,69.18 176.75,68.87 176.75,67.15 177.48,66.41 177.48,63.42 178.4,62.5 178.4,61.16 v2(178.66,60.9)
  BOTTOM w0.127: v2(178.66,60.9) 177.93,61.63 CE70.1 RE87.1
UPD_SMBINT#: length 186.8
  TOP w0.076: v2(25.04,61.71) 25.24,61.71 25.33,61.8 U722.B6
  TOP w0.127: v2(175.08,61.48) 174.7,61.48 RE3.2 CE72.2 174.28,62.96 174.72,62.52 UE5.A42
  IN3 w0.089: v2(171.83,73.12) 171.65,73.3 171.65,76.61 169.63,78.63 155.68,78.63 155.51,78.8 152.01,78.8 151.22,79.59 128.89,79.59 128.8,79.5 92.19,79.5 89.43,76.74 84.01,76.74 83.46,76.18 80.46,76.18 79.4,77.25 77.06,77.25 76.06,78.25 73.49,78.25 73.15,78.59 72.53,78.59 72.35,78.41 71.21,78.41 69.8,79.83 62.14,79.83 61.44,79.14 57.69,79.14 51.87,73.31 51.87,72.07 50.86,71.07 50.86,69.85 48.56,67.55 37.78,67.55 36.59,66.36 32.81,66.36 32.44,66.73 32.44,67.01 31.9,67.55 30.53,67.55 29.6,66.62 29.29,66.62 28.27,65.6 28.27,62.35 27.71,61.79 27.71,61.53 26.84,60.66 26.36,60.66 25.31,61.71 v2(25.04,61.71)
  IN4 w0.081: v2(171.83,73.12) 171.83,73.08 173.38,71.53 173.38,68.82 174.02,68.19 174.02,66.68 173.56,66.23 173.56,64.53 173.65,64.44 173.65,62.84 175.01,61.48 v2(175.08,61.48)
USB1_DET#: length 44
  TOP w0.127: v2(201.65,21.9) 202.2,22.46 v1(202.91,22.46)
  IN4 w0.081: v2(189.91,49.36) 189.91,49.33 193.29,45.96 193.29,34.12 193.68,33.72 194.87,33.72 195.58,33 195.58,25.96 198.1,23.45 200.1,23.45 v2(201.65,21.9)
  BOTTOM w0.127: JIO1.36 199.71,18.83 199.86,18.97 199.86,19.78 201.65,21.58 v2(201.65,21.9) ; v2(189.91,49.36) 190.53,49.36 190.78,49.1 191.51,49.1 191.95,49.55 CE22.1 RE34.2
USB2_EN: length 5.6
  TOP w0.127: v3(26.04,51.62) 25.6,51.62 25.16,51.18 US2.4 23.6,51.18 23.47,51.32 23.47,51.82 23.67,52.03 R1216.1 23.76,52.88 24.85,52.88 U699.4
USB2_ID: length 8.1
  BOTTOM w0.127: UCPU1.AG3 150.82,58.18 151.12,57.88 152.26,57.88 152.61,58.23 153.86,58.23 154.77,57.31 155.42,57.31 RC19.1 155.65,57 156.03,56.61 157.67,56.61 v3(157.87,56.81)
USB2_PWR_EN: length 242.4
  TOP w0.127: U699.1 26.15,54.73 26.15,54.56 25.4,53.81 RC293.2 23.67,54.23 v2(23.4,54.5) ; v3(39.98,39.05) 41.32,40.39 v2(42.11,40.39)
  IN1 w0.081: v2(42.11,40.39) 41.35,41.16 41.35,43.24 42.31,44.2 v2(42.34,44.2)
  IN4 w0.081: v2(23.4,54.5) 23.62,54.29 23.62,52.15 23.19,51.72 23.19,43.2 24.83,41.56 25.64,41.56 25.93,41.27 27.08,41.27 28.53,42.72 29.38,42.72 29.86,42.24 31.08,42.24 31.97,43.13 34.94,43.13 35.51,43.7 41.83,43.7 v2(42.34,44.2) ; v2(154.37,46.87) 154.37,46.47 155.5,45.33 155.5,42.88 156.47,41.91 156.47,41.09 160.22,37.35 160.22,35.93 162.22,33.93 162.92,33.93 163.52,33.33 163.52,31.45 161.67,29.6 161.67,27.15 163.13,25.69 163.13,22.93 160.51,20.32 148.06,20.32 147.66,20.72 144.98,20.72 144.5,20.24 125.46,20.24 124.06,21.64 117.7,21.64 116.95,20.89 111.72,20.89 110.64,21.97 100.95,21.97 99.77,23.15 98.83,23.15 97.73,24.25 97.73,25.53 97.64,25.62 97.64,29.35 96.82,30.17 96.82,33.58 95.63,34.78 90.9,34.78 90.09,35.59 85.3,35.59 83.82,34.11 83.82,33.57 82.48,32.23 78.69,32.23 77.61,31.15 76.78,31.15 73.94,28.31 71.48,28.31 68.91,25.74 68.91,24.55 65.93,21.57 60.09,21.57 58.94,22.72 53.91,22.72 52.92,23.71 50.92,23.71 50.79,23.59 45.2,23.59 41.24,27.55 41.24,31.63 41.09,31.78 41.09,33.54 39.95,34.68 39.82,34.68 39.23,35.28 39.23,37.04 41.26,39.07 41.45,39.07 42.24,39.85 42.24,40.27 v2(42.11,40.39)
  BOTTOM w0.076: v2(154.37,46.87) 154.12,46.87 153.18,47.81 150.65,47.81 150.09,48.37 149.19,48.37 148.15,49.41 148.15,49.79 148.19,49.9 148.2,50.05 148.16,50.2 148.16,50.4 148.19,50.52 148.21,50.55 148.26,50.68 UCPU1.AY7
USB3RN1: length 110
  IN2 w0.076: 149.36,67.67 149.33,67.7 149.14,67.7 148.46,68.38 148.46,68.73 148.23,68.96 147.9,68.96 147.68,68.73 147.68,68.35 147.43,68.1 147.35,68.1 v2(147.17,67.92)
  IN2 w0.102: 149.36,67.67 151.36,67.67 152.22,68.54 155.24,68.54 155.82,69.12 157.74,69.12 158.71,68.15 158.71,67.3 160.09,65.92 166.6,65.92 166.67,65.85 172.43,65.85 172.94,66.35 176.63,66.35 178.12,64.86 181.68,64.86 182.91,63.64 187.44,63.64 189.14,61.94 189.14,61.39 189.21,61.32 189.21,58.77 189.46,58.52 189.46,53.89 186.55,50.98 186.55,49.58 186.12,49.15 186.12,48.24 186.61,47.75 187.01,47.75 188.64,46.12 190.07,46.12 190.32,45.87 190.32,32.19 201.83,20.68 201.94,20.68 205.65,16.98 209.54,16.98 210.15,17.58 v2(210.15,17.63)
  BOTTOM w0.127: v2(210.15,17.63) 210,17.63 209.76,17.87 209.76,18.08 209.91,18.23 JIO1.2 ; v2(147.17,67.92) 147.45,67.64 UCPU1.H8
USB3RN2: length 164.9
  IN1 w0.076: v2(148.12,67.33) 147.91,67.53 147.76,67.53 147.53,67.77 147.53,68.88 147.64,68.99 147.64,69.41 147.43,69.62 147.42,69.62 147.41,69.62 147.4,69.63
  IN1 w0.091: v2(24.31,38.91) 24.59,39.19 24.68,39.19 24.88,39.39 24.88,41.24 30.29,46.65 30.29,46.86 31.22,47.8 31.22,53.87 30.72,54.37 30.72,62.32 30.16,62.88 30.16,63.99 31.81,65.64 33.61,65.64 34.55,66.58 36.72,66.58 37.33,67.19 40.79,67.19 47.05,73.45 60.96,73.45 61.78,72.62 63.75,72.62 64.21,72.17 69.14,72.17 70.33,73.36 80.21,73.36 80.39,73.54 85.9,73.54 86.69,74.33 91.43,74.33 93.18,76.08 93.18,77.16 94.06,78.04 108.08,78.04 108.88,77.24 115.19,77.24 115.46,77.5 119.58,77.5 120.15,78.07 139.69,78.07 140.91,76.85 144.99,76.85 147.04,74.8 147.04,69.99 147.4,69.63
  BOTTOM w0.127: v2(24.31,38.91) 24.07,38.91 23.45,38.29 ML13.1 ; v2(148.12,67.33) 148.46,66.99 UCPU1.J6
USB3RN2_RC_CON: length 12.1
  BOTTOM w0.127: ML13.2 21.01,38.29 20.74,38.56 20.5,38.56 19.89,39.18 19.58,39.18 19.5,39.09 DI1.10 DI1.1 17.28,39.09 17.04,39.34 16.95,39.42 16.87,39.52 16.87,39.53 16.78,39.63 16.78,39.75 15.5,41.04 15.5,42.03 15.09,42.44 13.88,42.44 13.31,41.87 12.87,41.87 12.72,41.73 12.72,41.54 12.72,41.54 JUSB2.5
USB3RP1: length 110.2
  IN2 w0.076: 149.36,67.89 149.33,67.86 149.21,67.86 148.63,68.45 148.63,68.79 148.3,69.13 147.83,69.13 147.51,68.8 147.51,68.41 147.37,68.27 147.25,68.27 147.12,68.4 147.12,68.6 v2(147.12,68.6)
  IN2 w0.102: v2(209.3,17.64) 209.41,17.75 209.58,17.75 209.68,17.65 209.68,17.43 209.45,17.2 205.75,17.2 202.04,20.91 201.92,20.91 190.55,32.28 190.55,45.96 190.16,46.35 188.73,46.35 187.1,47.97 186.7,47.97 186.34,48.34 186.34,49.06 186.77,49.49 186.77,50.88 189.69,53.8 189.69,58.61 189.43,58.86 189.43,61.42 189.36,61.49 189.36,62.03 187.54,63.86 183,63.86 181.77,65.08 178.21,65.08 176.72,66.58 172.84,66.58 172.34,66.07 166.76,66.07 166.69,66.15 160.19,66.15 158.94,67.4 158.94,68.24 157.83,69.35 155.73,69.35 155.14,68.76 152.13,68.76 151.26,67.89 149.36,67.89
  BOTTOM w0.127: v2(147.12,68.6) 147.42,68.29 UCPU1.G8 ; JIO1.4 209.31,18.41 209.31,18.31 209.51,18.11 209.51,17.85 v2(209.3,17.64)
USB3RP2: length 164.8
  IN1 w0.076: v2(148.11,67.93) 148.11,67.89 147.93,67.7 147.83,67.7 147.69,67.83 147.69,68.81 147.8,68.92 147.8,69.48 147.55,69.74 147.55,69.76 147.54,69.76
  IN1 w0.091: v2(24.31,39.49) 24.42,39.38 24.6,39.38 24.69,39.47 24.69,41.32 30.09,46.73 30.09,46.94 31.03,47.88 31.03,53.79 30.53,54.29 30.53,62.24 29.97,62.8 29.97,64.07 31.73,65.83 33.53,65.83 34.47,66.78 36.64,66.78 37.25,67.38 40.71,67.38 46.97,73.64 61.04,73.64 61.86,72.82 63.83,72.82 64.29,72.36 69.06,72.36 70.25,73.56 80.13,73.56 80.31,73.73 85.82,73.73 86.61,74.52 91.35,74.52 92.99,76.16 92.99,77.24 93.98,78.23 108.16,78.23 108.96,77.43 115.11,77.43 115.38,77.7 119.5,77.7 120.07,78.27 139.77,78.27 140.99,77.05 145.07,77.05 147.23,74.88 147.23,70.07 147.54,69.76
  BOTTOM w0.127: UCPU1.H6 148.38,67.64 148.11,67.9 v2(148.11,67.93) ; ML13.4 23.72,39.09 24.12,39.49 v2(24.31,39.49)
USB3RP2_RC_CON: length 12.3
  BOTTOM w0.127: ML13.3 21.01,39.09 20.74,38.82 20.61,38.82 v4(20.32,39.1) 20,39.43 19.61,39.43 19.45,39.59 DI1.9 DI1.2 17.14,39.59 17.1,39.64 17.06,39.69 17.04,39.72 17.04,39.86 15.75,41.14 15.75,42.13 15.19,42.69 14.98,42.69 13.78,42.69 13.2,42.12 12.87,42.12 12.72,42.26 12.72,43.11 JUSB2.6
USB3TN1: length 111.4
  IN2 w0.102: v2(208.1,17.66) 207.95,17.82 207.95,18.45 193.21,33.19 193.21,46.04 191.92,47.33 191.92,53.09 192.13,53.3 192.13,56.92 191.33,57.71 191.33,60.17 191.15,60.35 191.15,63.02 190.89,63.29 190.89,63.84 190.11,64.62 189.41,64.62 188.32,65.72 188.32,66.13 185.72,68.73 178.59,68.73 177.9,69.41 177.9,69.56 177.38,70.08 175.82,70.08 175.47,69.73 173.45,69.73 173,69.28 167.67,69.28 167.4,69.54 166.3,69.54 166.24,69.47 166.04,69.27 164.62,69.27 163.4,70.49 160.96,70.49 159.69,71.76 158.5,71.76 158.01,72.25 156.4,72.25 155.18,73.47 148.8,73.47 148.54,73.21 145.25,73.21 144.37,74.1 144.02,74.1 v2(143.87,74.25)
  BOTTOM w0.076: v2(143.87,74.25) 144.07,74.05 144.37,74.05 144.72,73.7 144.72,72.21 144.78,72.09 144.78,71.94 144.72,71.75 144.72,71.57 144.76,71.45 144.89,71.32 145.09,71.32 145.21,71.21 145.21,71.08 145.15,71.01 UCPU1.C13
  BOTTOM w0.127: v2(208.1,17.66) 207.92,17.84 207.92,17.99 208.11,18.18 JIO1.8
USB3TN2: length 163.1
  IN1 w0.091: v2(145.8,73.82) 145.58,74.04 145.35,74.04 143.15,76.23 140.23,76.23 139.01,77.45 120.88,77.45 120.32,76.89 115.7,76.89 115.39,76.59 109.32,76.59 107.32,74.59 107.32,73.69 105.29,71.67 102.66,71.67 100.1,74.23 100.1,76.49 99.17,77.43 94.89,77.43 94.62,77.15 94.62,76.01 92.32,73.72 87.02,73.72 85.81,72.51 79.97,72.51 79.76,72.73 70.56,72.73 69.41,71.58 63.83,71.58 63.41,72 61.54,72 60.69,72.86 47.3,72.86 40.96,66.52 40.96,66.01 40.25,65.29 37.18,65.29 36.51,65.96 34.8,65.96 33.81,64.97 31.97,64.97 30.84,63.83 30.84,63.05 31.4,62.48 31.4,57.98 32.23,57.14 32.23,55.96 31.9,55.63 31.9,47.59 30.88,46.57 30.88,46.4 27.02,42.54 27.02,41.07 26.66,40.71 25.56,40.71 v2(25.3,40.45)
  BOTTOM w0.076: v2(145.8,73.82) 145.69,73.93 145.47,73.93 145.4,73.85 145.4,73.41 145.59,73.21 145.59,72.22 145.34,71.97 145.16,71.97 144.99,71.79 UCPU1.B13
  BOTTOM w0.127: C621.1 24.79,40.65 25.09,40.65 v2(25.3,40.45)
USB3TN2_C: length 1.6
  BOTTOM w0.127: ML12.1 22.5,40.58 22.71,40.79 23.03,40.79 23.47,40.34 C621.2
USB3TN2_RC_CON: length 14.5
  BOTTOM w0.127: ML12.2 20.05,40.58 19.91,40.71 19.59,40.71 19.47,40.59 19.18,40.59 19.18,40.59 DI1.7 DI1.4 17.74,40.59 17.16,40.59 17.04,40.71 16.81,40.71 16.59,40.93 16.27,41.25 16.27,45.92 14.67,47.52 13.56,47.52 13.12,47.96 12.87,47.96 12.72,47.82 JUSB2.8
USB3TP1: length 111.3
  IN2 w0.102: v2(143.87,73.62) 143.87,73.72 144.01,73.87 144.27,73.87 145.16,72.99 148.64,72.99 148.89,73.24 155.09,73.24 156.31,72.02 157.92,72.02 158.4,71.54 159.6,71.54 160.87,70.27 163.31,70.27 164.53,69.05 166.13,69.05 166.39,69.31 167.31,69.31 167.57,69.05 173.09,69.05 173.55,69.5 175.56,69.5 175.92,69.86 177.28,69.86 177.68,69.46 177.68,69.32 178.5,68.5 185.63,68.5 188.09,66.04 188.09,65.63 189.32,64.4 190.02,64.4 190.67,63.75 190.67,63.19 190.93,62.93 190.93,60.26 191.11,60.08 191.11,57.62 191.9,56.83 191.9,53.39 191.69,53.19 191.69,47.24 192.99,45.95 192.99,33.09 207.72,18.36 207.72,17.81 207.57,17.66 v2(207.49,17.66)
  BOTTOM w0.076: v2(143.87,73.62) 143.87,73.74 144.01,73.89 144.3,73.89 144.56,73.63 144.56,72.18 144.59,72.08 144.59,71.89 144.56,71.8 144.56,71.55 144.62,71.35 144.62,71.35 144.65,71.22 144.68,71.14 144.7,71.07 144.7,70.96 144.75,70.78 144.75,70.6 UCPU1.D13
  BOTTOM w0.127: JIO1.10 207.51,18.25 207.67,18.09 207.67,17.81 207.52,17.66 v2(207.49,17.66)
USB3TP2: length 163.1
  IN1 w0.091: v2(25.3,41.08) 25.48,40.9 26.58,40.9 26.82,41.15 26.82,42.62 30.68,46.48 30.68,46.65 31.71,47.67 31.71,55.71 32.04,56.04 32.04,57.06 31.2,57.9 31.2,62.4 30.64,62.97 30.64,63.91 31.89,65.16 33.73,65.16 34.72,66.15 36.59,66.15 37.26,65.48 40.17,65.48 40.77,66.09 40.77,66.6 47.22,73.05 60.77,73.05 61.62,72.2 63.49,72.2 63.91,71.77 69.33,71.77 70.48,72.92 79.84,72.92 80.05,72.7 85.73,72.7 86.94,73.91 92.24,73.91 94.42,76.09 94.42,77.23 94.81,77.62 99.25,77.62 100.29,76.57 100.29,74.31 102.74,71.87 105.21,71.87 107.12,73.77 107.12,74.67 109.24,76.78 115.31,76.78 115.62,77.09 120.24,77.09 120.8,77.65 139.09,77.65 140.31,76.43 143.23,76.43 145.43,74.24 145.58,74.24 v2(145.8,74.46)
  BOTTOM w0.076: v2(145.8,74.46) 145.8,74.33 145.56,74.1 145.41,74.1 145.23,73.92 145.23,73.34 145.43,73.14 145.43,72.29 145.27,72.13 145.17,72.13 UCPU1.A13
  BOTTOM w0.127: C623.1 24.81,40.91 25.12,40.91 v2(25.3,41.08)
USB3TP2_C: length 1.6
  BOTTOM w0.127: C623.2 23.22,41.23 23.03,41.04 22.71,41.04 22.37,41.38 ML12.4
USB3TP2_RC_CON: length 14.6
  BOTTOM w0.127: 18.89,41.09 DI1.6 ; 18.89,41.09 17.74,41.09 ; 18.89,41.09 19.47,41.09 19.59,40.97 19.9,40.97 20.31,41.38 ML12.3 ; 17.74,41.09 DI1.5 ; 17.74,41.09 17.16,41.09 17.04,40.97 16.91,40.97 16.52,41.36 16.52,46.02 14.77,47.77 13.67,47.77 13.23,48.22 12.87,48.22 12.72,48.36 JUSB2.9
USB20_N1: length 95.3
  IN2 w0.102: v2(200.33,19.62) 200.48,19.47 200.48,19.34 200.34,19.2 199.01,19.2 196.63,21.57 196.63,22.3 194.54,24.4 194.54,26.45 193.6,27.39 192.06,27.39 189.86,29.59 189.86,34.34 186.61,37.59 186.61,46.74 185.28,48.07 185.28,52.4 186.26,53.38 186.26,55.5 185.34,56.42 185.34,57.51 184.07,58.78 180.02,58.78 177.93,56.68 176.52,56.68 172.5,60.7 167.2,60.7 164.56,63.35 163.34,63.35 163.14,63.15 159.87,63.15 159.64,62.91 159.64,62.67 159.46,62.48 v2(159.46,62.47)
  IN4 w0.091: v2(147.74,60.7) 147.71,60.73 147.6,60.73 147.5,60.62 147.5,60.36 147.6,60.26 151.78,60.26 153.3,61.78 156.19,61.78 156.7,61.26 159.33,61.26 159.73,61.66 159.73,61.99 159.67,62.04 159.34,62.04 159.23,62.15 159.23,62.41 159.31,62.48 159.44,62.48 v2(159.46,62.47)
  BOTTOM w0.127: UCPU1.AB9 147.44,61 v2(147.74,60.7) ; JIO1.34 200.31,18.63 200.47,18.79 200.47,19.48 v2(200.33,19.62)
USB20_N2: length 180.1
  IN1 w0.091: v2(24.94,44.27) 25.12,44.09 26.62,44.09 29.51,46.97 29.51,47.19 29.94,47.62 29.94,48.61 30.43,49.11 30.43,52.56 29.17,53.82 29.17,64.11 31.58,66.52 33.35,66.52 34.2,67.37 36.38,67.37 37.04,68.03 40.52,68.03 46.87,74.38 51.82,74.38 52.64,75.21 57.21,75.21 58.18,74.24 61.27,74.24 62.06,73.45 64.13,73.45 64.62,72.96 68.8,72.96 70,74.17 79.5,74.17 80.77,75.44 83.85,75.44 85.31,76.89 90.61,76.89 93.17,79.46 150.47,79.46 151.51,78.42 151.51,76.69 153.12,75.08 153.83,75.08 154.65,74.26 154.65,71.06 154.97,70.74 154.97,70.07 154.52,69.63 154.52,68.69 154.79,68.43 154.79,66.72 152.55,64.48 152.55,62.77 150.08,60.3 149.74,60.3 149.41,59.97 149.41,59.79 v2(149.62,59.58)
  BOTTOM w0.127: v2(149.62,59.58) 149.39,59.81 UCPU1.AD6 ; ML11.1 24.32,44.23 24.43,44.12 24.79,44.12 v2(24.94,44.27)
USB20_N2_CONN: length 11.6
  IN4 w0.091: JUSB2.2 14.23,45.3 14.32,45.21 15.44,45.21 16.46,44.18 16.81,44.18 v2(17.07,44.44)
  BOTTOM w0.127: v2(17.07,44.44) 17.29,44.21 17.64,44.21 17.65,44.21 18.43,44.99 DI2.3 18.49,44.52 18.81,44.2 19.14,44.2 19.93,44.98 21.22,44.98 22.06,44.14 22.25,44.14 22.33,44.23 ML11.2
USB20_N3: length 155.8
  IN1 w0.091: v2(153.59,57.13) 153.45,57.27 153.45,57.53 153.12,57.86 152.79,57.86 151.38,59.27 150.29,59.27 150.19,59.17 144.34,59.17 144.22,59.29 140.23,59.29 139.11,60.41 139.11,63.28 138.5,63.89 138.5,64.47 138.97,64.95 138.97,67.15 138.01,68.12 123.6,68.12 123.22,67.73 123.22,66.92 122.88,66.59 121.48,66.59 121.26,66.8 121.26,67.36 120.86,67.77 118.96,67.77 116.88,69.84 114.62,69.84 114.28,69.49 114.28,68.92 114.02,68.67 112.12,68.67 110.97,67.52 109.75,67.52 109.59,67.69 109.01,67.69 108.67,67.34 107.86,67.34 107.14,66.63 100.58,66.63 99.29,67.92 83.56,67.92 82.22,66.57 81.06,66.57 80.27,67.36 79.6,67.36 78.37,66.13 65.46,66.13 64.34,65 64.34,62.44 63.78,61.87 62.76,61.87 59.6,58.71 59.6,56.73 56.42,53.55 52.84,53.55 49.84,50.55 49.84,48.78 45.11,44.05 45.11,39.37 41.5,35.77 41.5,35.39 41.05,34.93 39.55,34.93 39.22,35.26 39.22,35.8 38.91,36.1 38.63,36.1 v2(38.46,36.28)
  BOTTOM w0.076: v2(153.59,57.13) 153.41,57.31 153.41,57.52 153.2,57.74 152.51,57.74 152.07,57.3 151.98,57.3 151.86,57.25 151.75,57.25 151.53,57.32 151.38,57.32 151.22,57.26 151.04,57.26 150.79,57.38 150.65,57.38 UCPU1.AH3
  BOTTOM w0.127: ML10.1 37.97,36.29 38.12,36.14 38.32,36.14 v2(38.46,36.28)
USB20_N3_R: length 6.7
  BOTTOM w0.127: ML10.2 36.42,36.42 36.22,36.62 35.97,36.62 35.87,36.52 35.87,36.32 35.75,36.2 35.22,36.2 35.04,36.39 35.04,36.89 v4(34.55,37.38) 34.16,37.77 32.28,37.77 32.14,37.92 32.14,38.04 32.25,38.16 JNGFF1.5
USB20_N4: length 100.8
  IN1 w0.091: v2(81.94,74.79) 81.74,74.79 81.62,74.67 81.62,74.5 81.78,74.34 85.54,74.34 87.04,75.84 90.52,75.84 93.54,78.87 150.2,78.87 150.92,78.15 150.92,76.44 152.89,74.47 153.6,74.47 153.95,74.12 153.95,73.39 153.76,73.21 153.76,68.32 152.66,67.23 152.2,67.23 151.87,66.89 151.87,62.95 150.04,61.12 146.91,61.12 146.66,60.87 146.66,60.51 146.89,60.28 147.29,60.28 147.51,60.05 147.51,59.81 v2(147.74,59.58)
  BOTTOM w0.127: UCPU1.AD9 147.44,59.89 v2(147.74,59.58) ; ML9.1 80.8,75.52 80.87,75.45 81.51,75.45 81.79,75.17 81.79,74.94 v2(81.94,74.79)
USB20_N4_CONN: length 10.6
  BOTTOM w0.127: JTS.3 72.03,76.16 72.33,75.85 72.86,75.85 73.14,75.58 73.14,75.17 73.27,75.04 73.65,75.04 DI4.3 74.54,75.24 74.69,75.09 74.9,75.09 76.48,76.66 77.39,76.66 77.54,76.51 v4(77.54,76.51) 77.96,76.09 77.96,75.74 78.18,75.52 ML9.2
USB20_N5: length 127.8
  IN1 w0.091: v2(153.6,55.84) 153.6,56.15 154.71,57.26 154.71,57.73 153.21,59.23 153.21,60.96 154.01,61.75 154.01,65.1 155.63,66.72 155.63,71.12 155.34,71.41 155.34,74.42 154.06,75.69 153.34,75.69 152.12,76.91 152.12,78.84 150.91,80.06 92.91,80.06 90.48,77.63 85.2,77.63 83.62,76.05 80.21,76.05 79.93,75.77 70.73,75.77 68.65,73.69 65.74,73.69 64.96,74.48 63.3,74.48 v2(63.14,74.63)
  BOTTOM w0.076: v2(153.6,55.84) 153.35,56.1 153.35,56.31 153.13,56.53 152.73,56.53 152.63,56.63 152.63,56.95 152.52,57.06 152.31,57.06 UCPU1.AJ1
  BOTTOM w0.127: v2(63.14,74.63) 63.35,74.43 63.95,74.43 64.26,74.12 64.26,73.06 63.52,72.32 62.34,72.32 62.09,72.07 62.09,71.81 62.22,71.69 L55.4
USB20_N5_CONN: length 10.3
  BOTTOM w0.127: JCAM.4 56.5,71.72 56.64,71.58 56.64,71.39 58.56,69.47 58.83,69.47 59.1,69.21 59.1,68.74 DI3.3 59.89,69.36 60.53,69.36 60.85,69.04 v4(61.08,69.04) 61.72,69.04 62.22,69.53 L55.3
USB20_P1: length 95.3
  IN2 w0.102: v2(200.91,19.62) 200.71,19.41 200.71,19.25 200.44,18.97 198.91,18.97 196.41,21.48 196.41,22.21 194.32,24.3 194.32,26.36 193.51,27.17 191.97,27.17 189.64,29.5 189.64,34.25 186.39,37.49 186.39,46.65 185.05,47.98 185.05,52.49 186.04,53.48 186.04,55.41 185.12,56.33 185.12,57.41 183.97,58.56 180.12,58.56 178.02,56.46 176.43,56.46 172.41,60.48 167.11,60.48 164.46,63.12 163.43,63.12 163.23,62.92 159.97,62.92 159.86,62.82 159.86,62.66 160.04,62.48 v2(160.04,62.47)
  IN4 w0.091: v2(147.1,60.7) 147.31,60.49 147.31,60.28 147.52,60.06 151.86,60.06 153.38,61.59 156.11,61.59 156.62,61.07 159.41,61.07 159.94,61.6 159.94,62.38 160.04,62.48 v2(160.04,62.47)
  BOTTOM w0.127: UCPU1.AB10 146.79,61.01 v2(147.1,60.7) ; v2(200.91,19.62) 200.73,19.43 200.73,18.79 200.91,18.6 200.91,18.41 JIO1.32
USB20_P2: length 180.1
  IN1 w0.091: v2(24.94,43.67) 25.17,43.9 26.7,43.9 29.7,46.89 29.7,47.11 30.13,47.54 30.13,48.53 30.62,49.03 30.62,52.64 29.36,53.9 29.36,64.03 31.66,66.32 33.43,66.32 34.28,67.18 36.46,67.18 37.12,67.84 40.6,67.84 46.95,74.19 51.9,74.19 52.72,75.01 57.13,75.01 58.1,74.05 61.19,74.05 61.98,73.26 64.05,73.26 64.54,72.77 68.88,72.77 70.08,73.97 79.58,73.97 80.85,75.24 83.93,75.24 85.39,76.7 90.69,76.7 93.25,79.27 150.39,79.27 151.32,78.34 151.32,76.61 153.04,74.89 153.75,74.89 154.46,74.18 154.46,70.98 154.78,70.66 154.78,70.15 154.33,69.71 154.33,68.61 154.6,68.35 154.6,66.8 152.35,64.56 152.35,62.85 150,60.49 149.66,60.49 149.22,60.05 149.22,59.63 149.18,59.59 v2(149.01,59.59)
  BOTTOM w0.127: ML11.4 24.34,43.73 24.47,43.86 24.74,43.86 v2(24.94,43.67) ; UCPU1.AD7 148.94,60.07 149.08,59.92 149.08,59.65 v2(149.01,59.59)
USB20_P2_CONN: length 11.6
  IN4 w0.091: v2(17.07,43.72) 16.8,43.99 16.38,43.99 15.36,45.01 14.32,45.01 14.23,44.92 JUSB2.3
  BOTTOM w0.127: ML11.3 22.29,43.73 22.13,43.89 21.95,43.89 21.12,44.73 20.03,44.73 19.25,43.94 18.99,43.94 18.49,43.44 DI2.2 18.44,43.06 17.54,43.96 17.31,43.96 v2(17.07,43.72)
USB20_P3: length 155.8
  IN1 w0.091: v2(153,57.13) 153.25,57.39 153.25,57.45 153.04,57.67 152.71,57.67 151.3,59.07 150.37,59.07 150.27,58.97 144.26,58.97 144.14,59.1 140.15,59.1 138.91,60.33 138.91,63.2 138.3,63.81 138.3,64.55 138.78,65.03 138.78,67.07 137.93,67.92 123.68,67.92 123.41,67.65 123.41,66.84 122.96,66.39 121.4,66.39 121.07,66.72 121.07,67.28 120.78,67.57 118.88,67.57 116.8,69.65 114.7,69.65 114.47,69.41 114.47,68.84 114.1,68.47 112.2,68.47 111.05,67.33 109.67,67.33 109.51,67.5 109.09,67.5 108.75,67.15 107.94,67.15 107.22,66.44 100.5,66.44 99.21,67.73 83.64,67.73 82.3,66.38 80.98,66.38 80.19,67.17 79.68,67.17 78.45,65.93 65.54,65.93 64.53,64.92 64.53,62.36 63.86,61.68 62.84,61.68 59.79,58.63 59.79,56.65 56.5,53.36 52.92,53.36 50.03,50.47 50.03,48.7 45.3,43.97 45.3,39.29 41.7,35.69 41.7,35.31 41.13,34.74 39.47,34.74 39.03,35.18 39.03,35.72 38.83,35.91 38.64,35.91 v2(38.43,35.7)
  BOTTOM w0.076: UCPU1.AJ3 150.6,56.87 150.5,56.97 150.5,57.13 150.58,57.21 150.76,57.21 150.9,57.15 151.02,57.09 151.18,57.09 151.19,57.1 151.25,57.1 151.41,57.15 151.5,57.15 151.72,57.09 151.89,57.09 152.01,57.14 152.14,57.14 152.58,57.57 153.13,57.57 153.25,57.45 153.25,57.38 153,57.14 v2(153,57.13)
  BOTTOM w0.127: ML10.4 37.96,35.79 38.05,35.89 38.24,35.89 v2(38.43,35.7)
