# Allegro board LAD841PR10-0621.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N56767132: length 3.2
  TOP w0.127: PC512.1 59.98,44.04 v3(58.48,45.54)
  TOP w0.508: PR505.2 PC512.1
N56767142: length 1.8
  BOTTOM w0.127: 89.22,17.03 PR504.1 88.67,16.44 v2(88.67,16.42)
  BOTTOM w0.254: PR504.1 PC511.2
N56767422: length 2.1
  BOTTOM w0.127: PR511.1 v3(62.71,37.18)
  BOTTOM w0.508: PC525.2 PR511.1
N56821674: length 3.4
  TOP w0.076: 26.31,59.37 26.26,59.43 26.26,59.57 26.1,59.72 25.26,59.72 U722.C10
  TOP w0.127: R1437.1 26.92,58.76 26.31,59.37
N56821678: length 11.9
  TOP w0.076: U722.H6 22.51,61.97 22.12,61.97 v2(21.98,61.84)
  TOP w0.127: v2(17.61,61.62) 17.88,61.35 R1438.1
  IN3 w0.089: v2(17.61,61.62) 18.45,62.46 18.45,65.15 18.99,65.69 20.43,65.69 21.28,64.84 21.28,62.53 v2(21.98,61.84)
N56822218: length 5.5
  TOP w0.076: 23.93,58.34 24.1,58.5 24.1,59.38 U722.E11
  TOP w0.127: 23.93,58.34 23.65,58.05 R1468.1 23.34,57.74 23.18,57.58 23.18,56.5 23.56,56.11 v1(23.56,55.88) 23.24,55.56 22.91,55.56 R1465.1
N56822254: length 4.9
  TOP w0.076: 20.42,61.22 21.74,61.22 21.84,61.32 22.36,61.32 U722.H7
  TOP w0.127: 20.42,61.22 v1(19.19,60) 19.01,59.81 C618.1
N56822270: length 1.3
  TOP w0.127: v2(23.14,63.46) 23.01,63.59 23.01,63.97 U722.G2
  BOTTOM w0.127: R1473.1 23.15,63.45 v2(23.14,63.46)
N56822627: length 7.5
  TOP w0.076: U722.G4 22.76,63.22 22.76,64.77 22.54,64.99 22.54,65.49
  TOP w0.127: TC29.1 21.61,68.25 22.08,67.78 22.65,67.78 22.92,67.51 22.92,65.95 22.54,65.56 22.54,65.49
N56822629: length 6.2
  TOP w0.076: 23.32,64.96 23.32,64.62 23.27,64.57 23.27,63.86 23.58,63.55 23.58,63.04 U722.F4
  TOP w0.127: 23.32,64.96 23.32,65.48 23.17,65.62 23.17,67.81 22.83,68.16 TC25.1
N56822683: length 2.8
  TOP w0.076: 23.67,58.43 23.9,58.66 23.9,59.14 23.76,59.29 23.76,59.68 24.01,59.93 U722.E10
  TOP w0.127: 23.67,58.43 23.55,58.32 23.38,58.32 23.12,58.05 TC36.1
N56822685: length 3
  TOP w0.076: 22.44,58.4 22.44,58.66 23.01,59.23 U722.G11
  TOP w0.127: TC38.1 22.43,56.95 22.43,58.39 22.44,58.4
N56856077: length 1.8
  TOP w0.076: U722.F1 23.55,64.51 23.55,65.79
  TOP w0.127: RT190.1 23.55,66.15 23.55,65.79
N56859240: length 5.5
  TOP w0.076: U722.F2 23.69,64.15 23.69,64.15 23.77,64.23 23.77,64.75 23.8,64.78
  TOP w0.127: v1(23.63,68.69) 23.88,68.69 24.4,68.17 R1471.2
  TOP w0.152: 23.8,64.78 23.8,65.46 24.17,65.82 24.17,67.75 R1471.2
N56859647: length 5.1
  TOP w0.076: 24.57,65.49 24.26,65.18 24.26,64.22 U722.E2
  TOP w0.127: 24.57,65.49 24.95,65.86 25.21,65.86 25.66,66.32 25.66,67.3 R1471.1
N56975718: length 1.2
  TOP w0.127: UE5.A10 189.13,64.02 T183.1
N56975734: length 1.1
  TOP w0.127: UE5.A23 183.36,68.72 183.36,69.68 T184.1
N56977728: length 2.8
  TOP w0.127: v1(187.28,49.26) 186.92,49.62 R60.1 186.41,48.93 186.41,48.93 U15.27
N56984382: length 2.3
  TOP w0.127: v2(184.16,67.15) 184.11,67.2 UE5.B23
  BOTTOM w0.127: v2(184.16,67.15) 184,67.32 T187.1
N56984398: length 1.3
  TOP w0.127: v2(178.61,64.02) 178.36,64.27 178.01,64.27 UE5.B41
  BOTTOM w0.127: v2(178.61,64.02) 178.56,63.97 T188.1
N56984414: length 3.3
  TOP w0.127: v2(184.32,60.33) 184.32,60.1 183.96,59.74 183.66,59.74 183.43,59.51 183.43,59.05 183.61,58.87 UE5.B62
  BOTTOM w0.127: v2(184.32,60.33) T189.1
N57034346: length 4.2
  BOTTOM w0.076: T124.1 153.49,59.03 152.69,59.83 152.12,59.83 152,59.76 151.63,59.76 151.51,59.84 150.96,59.84 150.61,60.18 UCPU1.AC3
N57034424: length 4.9
  TOP w0.076: 27.03,60.9 27.03,61.22 26.8,61.45 26.39,61.45 26.17,61.23 24.75,61.23 U722.D7
  TOP w0.127: 27.03,60.9 27.39,60.54 28.05,60.54 R1439.1
N57037386: length 2.9
  TOP w0.127: QT19.1 31.67,61.44 R1440.1 31.67,62.1 30.86,62.91 v1(30.57,62.91)
N57146881: length 10.5
  BOTTOM w0.076: T192.1 141.66,42.63 140.33,43.96 140.33,46.4 139.81,46.92 139.81,47.89 139.64,48.06 139.64,48.61 139.83,48.8 139.83,49.16 139.52,49.46 139.52,49.83 139.54,49.86 139.57,49.94 139.57,50.06 139.51,50.27 139.51,50.42 139.56,50.58 139.56,50.66 139.74,51.22 139.96,51.44 UCPU1.AW22
N57177583:
  vias: v3(152.91,76.38)
N57177874: length 1.2
  TOP w0.127: RZ76.2 165.88,48.79 164.81,48.79 UZ22.4
N57177931: length 2.1
  TOP w0.127: v3(160.94,45.47) 161.21,45.74 161.21,46.39 161.39,46.58 161.39,47.36
N57178338:
  vias: v3(162.56,65.04)
N57182329: length 3.7
  TOP w0.127: v1(36.31,72.11) 36.31,73.13 PR228.2 35.76,73.2 34.46,73.2 34.22,73.43 PQ207.5
N57280922: length 4.4
  TOP w0.076: 27.28,60.29 26.9,60.66 26.26,60.66 26.21,60.71 25.75,60.71 U722.B9
  TOP w0.127: 27.28,60.29 27.29,60.28 27.5,60.28 v2(28.38,59.41)
  BOTTOM w0.127: T193.1 28.38,59.4 v2(28.38,59.41)
N57280925: length 2.8
  TOP w0.076: 27.28,59.93 26.74,60.47 26.01,60.47 U722.A9
  TOP w0.127: 27.28,59.93 27.75,59.46 v2(27.75,59.41)
  BOTTOM w0.127: v2(27.75,59.41) 28.07,59.08 T194.1
N57281646: length 1.3
  TOP w0.127: T185.1 181.46,57.1 181.86,57.51 UE5.A55
N57313034: length 3.5
  TOP w0.127: v2(147.2,53.11) 146.81,52.72 146.81,52.26 147.8,51.27 RC49.2
  BOTTOM w0.076: UCPU1.AT8 147.54,53.45 v2(147.2,53.11)
N57313074: length 3.6
  TOP w0.127: 149.58,50.83 149.58,51.56 v3(149.36,51.78) 149.14,52 148.94,52 148.56,52.38 148.56,52.67 v2(148.12,53.11)
  BOTTOM w0.127: v2(148.12,53.11) 147.94,53.11 UCPU1.AU8
N57317696: length 9.1
  TOP w0.127: v2(165.33,49.23) 165.23,49.34 161.21,49.34 v3(161,49.13) 161,48.86 160.41,48.27 159.97,48.27 159.77,48.47 159.01,48.47 158.78,48.7 158.78,49.2 RC9.2
  BOTTOM w0.127: v2(165.33,49.23) 165.9,48.66 SW1.1
N57319429: length 1.8
  TOP w0.127: v2(117.65,57.51) 117.45,57.31 117.3,57.31 T195.1
  BOTTOM w0.254: UCPU1.AK62 117.34,57.13 117.65,57.44 v2(117.65,57.51)
N57319432: length 1.9
  TOP w0.127: v2(118.24,57.49) 118.24,56.75 T196.1
  BOTTOM w0.254: UCPU1.AL61 117.86,56.57 117.86,57.09 118.24,57.46 v2(118.24,57.49)
N57408632: length 6.5
  TOP w0.127: UT1.F19 39.9,63.76 v2(39.58,63.44) ; v2(39.17,66.69) 39.17,66.98 39.04,67.12 RT164.2
  BOTTOM w0.127: v2(39.58,63.44) 40.24,63.44 40.67,63.88 40.67,64.26 40.13,64.8 39.79,64.8 v1(39.29,65.31) 38.77,65.82 38.77,66.29 v2(39.17,66.69)
N57526872: length 17.7
  TOP w0.076: v2(22.91,58.56) 22.91,58.84 23.27,59.19 23.27,59.73 U722.F10
  TOP w0.152: v2(19.66,68.54) 19.5,68.7 RT201.1
  IN1 w0.081: v2(19.66,68.54) 19.18,68.06 19.18,67.19 22.32,64.05 22.32,62.75 22.4,62.67 22.4,61.58 21.55,60.73 21.55,59.91 v2(22.91,58.56)
  BOTTOM w0.127: v2(22.91,58.56) 22.91,58.06 RT199.1 ; v2(22.91,58.56) 22.68,58.56 22.34,58.9 RT200.1 ; v2(22.91,58.56) 23.04,58.56 23.31,58.28 v1(23.51,58.28)
N57670088: length 2.1
  TOP w0.127: v2(143.49,53.15) 143.37,53.15 T116.1
  BOTTOM w0.127: UCPU1.AW15 143.52,53.11 v2(143.49,53.15)
N57912451: length 23.4
  IN3 w0.203: v2(75.79,59.01) 75.79,58.84 75.92,58.71 76.57,58.71 77.07,58.2 77.5,58.2 78.41,59.11 79.75,59.11 80.29,59.66 80.29,60.8 80.94,61.45 85.51,61.45 85.84,61.12 89.5,61.12 90.3,61.92 90.3,62.67 v2(90.02,62.95)
  BOTTOM w0.127: v2(75.79,59.01) 76.67,58.14 v3(76.67,56.74)
  BOTTOM w0.203: v2(75.79,59.01) 75.03,58.25 PR1102.1 ; PR1130.2 v2(90.02,62.95)
N57965459: length 1.2
  BOTTOM w0.127: v3(57.35,55.48) 57.11,55.71 PQ201.2
N58401690: length 1
  BOTTOM w0.127: RE107.1 179.05,55.94 T197.1
N58453857: length 4.2
  TOP w0.127: R536.2 201.62,14.36 v3(202.9,15.63) 203.23,15.96 203.23,17.6 Q71.1
N58842401: length 1.8
  TOP w0.127: T125.1 149.63,57.99 v2(149.63,58.53)
  BOTTOM w0.127: v2(149.63,58.53) 149.78,58.68 149.78,59.09 150.17,59.47 UCPU1.AD4
N58864976: length 4.9
  TOP w0.127: v3(180.57,37.17) 180.57,35.53 180.16,35.12 R1445.2 R1446.2 179.17,34.15 179.28,34.04 U717.5
N59153523: length 6.4
  TOP w0.127: U15.3 183.11,46.07 183.63,46.07 183.73,46.18 183.73,47.23 183.57,47.4 183.57,48.72 183,49.29 R1006.2 182.15,49.29 181.53,49.91 v1(181.53,50.47)
N59418764: length 4.1
  TOP w0.076: U722.C2 25.27,64.23 25.27,64.57 25.32,64.63 25.32,64.8
  TOP w0.127: 25.32,64.8 25.32,65.06 25.63,65.36 25.63,65.9 26.11,66.38 26.95,66.38 R1436.1
N59418771: length 3.1
  TOP w0.076: 26.19,64.22 25.76,64.22 U722.B2
  TOP w0.127: 26.19,64.22 26.8,64.83 26.8,65.46 26.37,65.89 TC35.1
N59894012: length 2.8
  TOP w0.127: U15.29 185.41,47.88 185.41,48.51 RE92.2 v3(183.57,49.28)
N59894959: length 1.6
  TOP w0.127: RC230.1 185.91,41.7 185.91,42.77 U15.13
N60736253: length 6.4
  TOP w0.127: PQ221.2 v3(53.67,38.39)
  TOP w0.381: PR276.1 54.76,35.65 PR275.2 PC218.2 55.27,37.47 PQ221.2
N60748906: length 10.3
  TOP w0.127: v3(54.39,30.96) 56.16,32.73 56.69,32.73 56.99,33.03 56.99,33.74 57.6,34.35 57.6,34.59 58.01,35 58.45,35 59.15,35.7 PR279.1
  TOP w0.381: PR279.1 59.33,35.73 PR278.2 61.78,35.73 PQ222.2
N60750593: length 5.1
  TOP w0.127: v3(55.98,31.64) 57.29,32.95 57.29,33.67 58.14,34.53 PQ223.3
  TOP w0.381: PQ223.3 59.04,34.53 PR279.2
N60753752: length 3.4
  TOP w0.127: PQ223.2 57.98,33.88 57.71,33.62 v3(57.71,31.98)
  TOP w0.381: PR277.2 59.23,33.88 PQ223.2
N60757042: length 5.1
  TOP w0.127: v3(53.32,54.76) 53.74,55.18 55.25,55.18 55.47,55.41 PQ206.5 55.47,56.04 55.65,56.22 56.3,56.22 56.93,55.58 PR280.1
N60757502: length 2.9
  TOP w0.381: PQ223.6 55.68,33.23 v3(55.43,33.49) 55.14,33.77 55.14,34.6 54.89,34.86 PR276.2
N60799582: length 25.3
  TOP w0.254: v2(63.93,46.64) 64.26,46.97 PR1067.2 65.13,46.97 PR1072.1
  IN4 w0.254: v2(83.82,50.99) 82.34,50.99 79.42,48.07 77.09,48.07 75.67,46.64 72.72,46.64 72.31,47.05 70.41,47.05 70,46.64 v2(63.93,46.64)
  BOTTOM w0.254: PH1007.2 83.59,50.76 v2(83.82,50.99)
N60799583: length 3.4
  TOP w0.203: v2(70.05,50.17) 69.96,50.27 PU1000.8
  BOTTOM w0.203: PC1088.2 71.1,50.35 70.23,50.35 v2(70.05,50.17)
  BOTTOM w0.254: PC1088.2 71.45,49.16 PR1061.2
N60799590: length 2.2
  TOP w0.127: PR1098.1 68.83,45.91 PC1014.2 69.83,46.03 v3(70.94,46.03)
N60799626: length 5.5
  TOP w0.203: PU1000.5 68.76,49.8 68.53,49.58 68.53,49.35 67.77,48.59 PR1093.2 67.77,47 PR1065.2 67.92,46.85 PR1098.2
N60799629: length 0.9
  TOP w0.127: PR1065.1 67.77,46.03 PC1095.2
N60799635: length 3.9
  TOP w0.203: PR1122.2 PC1021.2 67.57,49.01 v3(68.1,49.53) 68.13,49.56 68.13,49.72 68.36,49.95 68.36,51.01 PU1000.4
N60799636: length 5.8
  TOP w0.127: v3(63.63,45.66) 63.9,45.39 66.23,45.39 66.42,45.57 66.42,46.44 PC1020.2 66.02,47.1 PR1122.1
N60799645: length 4.2
  TOP w0.203: PR1072.2 65.63,49.51 67.45,49.51 67.96,50.02 PU1000.3
N60799650: length 3.9
  TOP w0.203: v2(67.41,50.12) 67.56,50.27 67.56,51.01 PU1000.2
  BOTTOM w0.127: v3(66.7,49.04) 66.7,49.42 v2(67.41,50.12)
  BOTTOM w0.203: v2(67.41,50.12) 67.67,50.38 PC1131.2 PR1099.2
N60799669: length 3
  BOTTOM w0.127: PC1088.1 72.37,50.01 72.97,50.61 73.76,50.61 v3(74.1,50.95)
  BOTTOM w0.203: PR1087.2 PC1088.1
N60799680: length 34.6
  IN2 w0.254: v2(91.05,42.16) 88.59,42.16 87.88,41.46 87.88,39.4 86.41,37.93 86.41,37.17 84.25,35.01 79.32,35.01 74.14,40.19 74.14,43.57 71.68,46.03 v2(71.53,46.03)
  BOTTOM w0.254: v2(71.53,46.03) 70.97,46.03 70.71,45.78 v3(70.54,45.78) 69.83,45.78 PR1088.2 ; v2(91.05,42.16) 90.79,42.16 90.15,42.81 PH1005.1
N60799687: length 3.1
  TOP w0.127: PR1028.1 63.3,54.7 v2(62.97,54.36) 62.64,54.7 PR1025.2
  BOTTOM w0.127: PR1074.2 63.25,54.36 v2(62.97,54.36) 62.58,54.36 v3(62.25,54.04)
N60799688: length 2.4
  TOP w0.203: PU1000.35 65.21,53.76 65.02,53.95 65.02,54.19 PR1028.2
N60799689: length 3.8
  TOP w0.127: PR1076.1 63.45,53.65 v2(62.97,53.65) 62.51,53.65 PR1024.2
  BOTTOM w0.127: v3(62.1,52.21) 62.1,52.79 v2(62.97,53.65) 63.42,53.65 PR1063.2
N60799690: length 2.1
  TOP w0.203: PR1076.2 64.96,53.36 PU1000.36
N60799691: length 5.7
  TOP w0.127: PR1125.2 v2(62.97,52.92) PR1070.1
  BOTTOM w0.127: v2(62.97,52.92) PR1084.2 63.58,51.58 63.85,51.31 v3(63.85,49.14)
N60799692: length 1.9
  TOP w0.203: PU1000.37 64.56,52.96 PR1070.2
N60799709: length 2.8
  TOP w0.203: PR1029.2 65,50.12 65.87,50.99 65.87,51.41 66.21,51.76 PU1000.40
N60799711: length 2.9
  TOP w0.203: PR1027.2 PR1095.2 64.69,52.08 65.26,52.08 65.34,52.16 PU1000.39
N60799723: length 4.6
  TOP w0.127: PR1094.1 63.97,56.1 63.24,56.1 63.11,56.23 v1(62.38,56.23)
  TOP w0.203: PR1094.1 65.28,55.58 65.9,54.96 PU1000.32
N60799725: length 3.8
  TOP w0.127: PR1121.1 64.49,56.91 65.06,57.48 v3(65.06,57.74)
  TOP w0.203: PU1000.31 66.41,55.36 65.98,55.36 64.75,56.6 PR1121.1
N60799730:
  vias: v2(62.35,63.84) v2(62.46,64.47) v2(72.87,65.52) v2(73.47,65.51)
N60799760: length 7.7
  IN3 w1.016: 62.71,61.93 62.87,61.78 64.21,61.78 64.64,62.21 69.98,62.21 70.08,62.32
  vias: v2(62.68,60.91) v2(62.68,60.33) v2(70.59,61.43) v2(70.97,61.93)
N60799765: length 6.4
  IN3 w1.016: 70.35,66.43 65.66,66.43 65,65.77 65,64.98
  vias: v2(65,64.22) v2(64.98,63.63) v2(70.31,65.44) v2(70.85,65.16)
N60799773: length 5.8
  TOP w0.127: PC1082.1 61.52,61.87 60.94,61.29 60.94,60.07 61.77,59.23 62.62,59.23 v1(63.14,58.71)
  TOP w0.508: PC1082.1 PR1082.1
N60799776: length 2.5
  TOP w0.508: PC1082.2 61.57,60.39 62.25,59.71 63.01,59.71 v3(63.49,60.19)
N60799787: length 1.4
  TOP w0.203: PR1059.1 63.3,64.63 63.47,64.46 PU1305.7
N60799795: length 4
  TOP w0.203: PR1085.1 PC1069.1 73.23,56.73 v3(72.63,56.13) 71.86,55.36 PU1000.20
N60799808: length 2.1
  TOP w0.127: v3(72.83,57.79) 72.97,57.64 PC1069.2
  TOP w0.203: PR1068.1 74.88,57.64 PC1069.2
N60799810: length 24.4
  IN4 w0.203: v2(76.51,54.34) 77.09,54.34 78.05,55.3 78.05,56.22 81.1,59.27 81.1,61.05 81.43,61.38 83.87,61.38 84.4,61.91 84.4,65.06 84.84,65.49 85.88,65.49 86.16,65.77 89.28,65.77 v2(89.84,66.33)
  BOTTOM w0.203: v2(89.84,66.33) 89.81,66.35 PH1009.1 ; v2(76.51,54.34) 76.4,54.24 PR1097.2
N60799827: length 4
  TOP w0.127: PR1083.2 64.26,49.01
  TOP w0.203: PU1000.1 67.16,50.63 66.47,49.95 v1(65.9,49.95) 65.33,49.95 64.87,49.49 64.75,49.49 64.26,49.01
N60799848: length 19.4
  TOP w0.127: v3(75.82,50.4) 75.44,50.78 v2(75.44,51.72)
  TOP w0.203: v2(75.44,51.72) 75.11,51.39 PR1126.2 74.73,52.23 PR1064.1
  IN3 w0.203: v2(75.44,51.72) 75.97,51.72 77.5,53.25 79.62,53.25 80.37,54 80.37,56.28 81.42,57.34 84,57.34 84.76,58.1 v2(84.76,60.21)
  BOTTOM w0.203: PH1008.2 v2(84.76,60.21)
N60799854: length 2.2
  BOTTOM w0.127: PR1123.1 v3(69.82,54.06)
  BOTTOM w0.203: PR1123.1 70.97,54.42 PC1064.2
N60799880: length 3.6
  TOP w0.127: PR1081.1 76.18,53.17 77.57,54.57 v3(77.57,54.95)
  TOP w0.203: PR1081.1 75.79,54.03 PC1090.2
N60799887: length 2
  TOP w0.127: v3(78.21,51.39) PC1096.1
  TOP w0.254: PC1096.1 77.06,52.26 PR1096.2
N60799908: length 2.2
  BOTTOM w0.127: PR1090.2 66.88,56.39 v3(66.06,57.21)
  BOTTOM w0.203: PR1090.2 66.88,55.36 PC1089.1
N60799928: length 2.2
  TOP w0.127: v3(69.52,60.41) PC1072.1 69.75,59.17 PR1073.2
N60799936: length 2.1
  TOP w0.127: PR1060.2 71.55,59.24 PC1134.1 v3(71.55,61.27)
N60799950: length 3.1
  TOP w0.203: PR1075.1 PC1068.1 v3(67.54,57.24) 67.54,57.16 67.96,56.74 PU1000.28
N60799960: length 7.2
  TOP w0.127: v3(71.86,63.46) 70.01,61.62 70.01,61.07 69.78,60.84 68.02,60.84 67.54,60.35 PR1092.1 PC1068.2
N60799970: length 9.9
  IN1 w0.203: v2(73.18,59.42) 65.35,59.42 v2(65,59.78)
  BOTTOM w0.203: v2(65,59.78) 64.87,59.65 PR1089.2 ; PH1006.1 73.58,59.01 v2(73.18,59.42)
N60799989: length 6.9
  TOP w0.127: v3(60.24,52.92) 60.76,52.4 61.86,52.4 PR1124.2
  TOP w0.203: PU1000.38 65.02,52.56 64.87,52.41 62.87,52.41 PR1124.2
N60799994: length 7.1
  TOP w0.203: v2(65.48,54.24) 65.56,54.16 PU1000.34
  BOTTOM w0.127: v3(65.71,50.67) 65.93,50.89 65.93,52.12 65.51,52.54 PC1007.1
  BOTTOM w0.203: PR1080.1 66.02,53.68 65.63,53.3 PC1007.1 65.51,54.21 v2(65.48,54.24)
N60799995: length 6
  TOP w0.203: v2(65.15,54.85) 65.53,54.85 65.82,54.56 66.41,54.56 PU1000.33
  BOTTOM w0.127: v3(62.47,56.41) 62.48,56.41 62.34,56.27 62.34,55.51 62.61,55.23 63.14,55.23 63.48,55.57 PR1066.1
  BOTTOM w0.203: v2(65.15,54.85) 65.15,55.18 PC1005.1 63.6,55.71 PR1066.1
N60800026: length 12.4
  BOTTOM w0.203: PR1136.2 74.98,61.93 74.98,60.57 74.67,60.26 72.43,60.26 72.43,60.25 v3(70.98,60.25) 70.13,60.25 69.52,60.87 67.18,60.87 66.93,61.12 66.19,61.12 65.7,60.63 PR1091.1
N61074629: length 7.6
  TOP w0.127: v3(193.76,45.89) 194.18,45.47 RH127.2 194.29,44.3 196.85,44.3 197.13,44.59 197.13,45.97 Q72.2
N61450237: length 3.1
  TOP w0.127: v3(204.35,31.05) R289.2
  TOP w0.305: U48.8 202.33,30.27 R289.2
N61547946: length 4.6
  TOP w0.127: R2670.1 v3(54.28,75.42)
  TOP w0.508: R2670.1 56.08,75.42 57.12,74.38 QZ9.1
N61553916: length 5.2
  TOP w0.127: R2671.1 55.54,78.25 55.03,78.77 55.03,79.84 v3(54.27,80.6)
  TOP w0.508: UZ26.6 56.55,78.43 56.37,78.25 R2671.1
N62098363:
  vias: v3(202.04,39.19)
N63073614: length 2.3
  TOP w0.127: PQ216.5 54.79,67.4 PR248.2 55.31,67.45 55.53,67.22 v3(56.03,67.22)
N63073655: length 1.2
  TOP w0.127: PQ217.5 51.72,70.82 51.54,71 PR251.2
N63092271: length 6
  TOP w0.127: v2(20.42,72.01) PQ209.2 20.42,73.29 PR217.2
  BOTTOM w0.127: v2(20.42,72.01) v3(20.42,68.41)
N63092515: length 4
  TOP w0.127: PR220.2 22.25,73.87 v1(22.25,73.01) 22.1,73.01 20.42,71.33 PQ209.5
N63216045: length 1
  TOP w0.127: QH8.6 6.25,7.75 R913.1
N63216077: length 7
  TOP w0.127: R912.1 6.52,8.59 6.64,8.72 6.64,9.29 6.82,9.47 9.42,9.47 10.07,10.12 v1(10.07,11.01) 10.07,11.2 9.8,11.47 9.05,11.47 QH9.3
N63216109: length 2.4
  TOP w0.127: QH9.6 6.88,10.17 R911.1 5.88,9.8 v1(5.88,10.5)
N63239426: length 2.1
  TOP w0.127: Q41.1 6.22,5.95 R910.1 v1(6.2,4.91)
N63254653: length 7.7
  TOP w0.127: v1(60.43,51.27) 60.43,51.09 61.07,50.44 61.58,50.44 PR218.1 62.21,49.82 62.21,48.47 62.46,48.22 PQ208.2 62.92,48.22 62.38,47.68 62.38,47.33 v2(61.67,46.62)
  BOTTOM w0.127: PR283.1 62.13,47.08 v2(61.67,46.62)
N63877984: length 4.3
  TOP w0.127: PQ208.5 60.87,48.22 60.22,47.57 PR282.1 59.17,47.57 v1(59.13,47.61) 59.13,47.88 59.39,48.13 59.39,48.88 PR229.1
N64008725: length 3.1
  TOP w0.127: QE13.6 QE13.5 159.23,39.89 R78.2 158.98,40.14 v3(157.68,40.14)
N64008885: length 2.5
  TOP w0.127: 159.88,37.23 QE13.3 ; 159.88,37.23 159.88,37.24 160.3,37.65 v3(161.06,37.65) ; 159.88,37.23 159.88,36.18 R79.2
N64546397: length 6.8
  TOP w0.127: PR284.2 59.54,60.99 59.54,61.46 58.78,62.23 PQ215.5 58.78,62.76 59.91,63.89 59.91,64.72 58.96,65.67 v3(58.78,65.67)
N64546409: length 68
  TOP w0.127: PD206.2 99.37,75.29 v2(99.59,75.51) v1(100.16,76.08)
  IN2 w0.089: v2(84.98,75.08) 85.01,75.04 87.06,75.04 88.49,76.47 91.4,76.47 92.74,77.81 98.97,77.81 99.59,77.19 v2(99.59,75.51)
  IN3 w0.089: v2(52.73,66.37) 52.39,66.37 52.02,66.73 52.02,69.36 53.83,71.17 53.83,74.36 57.96,78.49 61.87,78.49 62.34,78.02 62.85,78.02 63.36,78.53 68.59,78.53 70.74,76.37 79.05,76.37 80.1,75.32 83.81,75.32 83.99,75.5 84.56,75.5 v2(84.98,75.08)
  BOTTOM w0.127: v2(52.73,66.37) 52.73,66.68 53.4,67.36 PR291.2 55,66.8 55,66.16 PR285.1
N64570632: length 13.5
  TOP w0.127: v2(58.36,63.24) 58.13,63.01 PQ215.4 58.13,62.03 PR286.2 ; v1(53.04,69.12) 53.04,68.33 53.33,68.05 PQ216.6 53.88,68.57 54.18,68.87 55.47,68.87 55.76,68.58 56.76,68.58 v2(56.86,68.49)
  IN1 w0.081: v2(56.86,68.49) 56.92,68.42 56.92,65.01 58.36,63.57 v2(58.36,63.24)
N64571386: length 9.3
  TOP w0.127: v2(53.21,65.32) 53.34,65.45 53.34,66.74 52.91,67.17 52.21,67.17 PQ216.2 52.17,67.4 52.49,67.71 52.49,68.22 51.75,68.95 v1(51.75,69.12) 51.75,69.41 51.05,70.11 PR247.1
  BOTTOM w0.127: PR285.2 53.86,65.27 53.86,65.68 53.73,65.81 53.45,65.81 53.21,65.57 v2(53.21,65.32)
N64571512: length 25.2
  TOP w0.127: PR286.1 57.71,61.53 57.71,62.81 57.6,62.92 v2(57.6,62.99) 57.6,63.43 58.13,63.96 PQ215.3 ; v2(55.22,74.57) 55.22,74.21 v1(55.04,74.04)
  IN4 w0.081: v2(55.22,74.57) 56.44,73.35 56.44,72.17 56.79,71.81 56.79,69.43 57.28,68.94 57.28,67.9 56.95,67.58 56.95,64.54 57.6,63.89 v2(57.6,62.99)
  BOTTOM w0.127: v2(55.22,74.57) 55.22,78.39 54.6,79.01 52.94,79.01 51.47,80.48 PR243.2
N64625473: length 19.7
  TOP w0.254: PQ218.3 88.43,67.25 88.68,67.25 89.4,67.97 89.4,68.58 89.23,68.74 89.23,69.85 PD203.1 89.08,70.32 88.49,69.73 85.95,69.73 PR258.1 85.83,69.81 85.02,69 83.67,69 v3(83.13,69.54) 82.71,69.54 81.46,70.79 81.46,71.97 PR264.2 PR268.1 PC211.1 85.23,73.96 PU201.5
N64625477: length 21.2
  TOP w0.127: v2(80.98,71.46) 80.98,70.73 83.17,68.54 85.07,68.54 85.7,67.9 PR252.2 86.59,68.72 PR265.1 ; PC212.1 PR258.2 86.28,70.32 PD203.2 ; PC212.1 85.46,71.29 87.23,71.29 87.56,71.63 87.56,72.35 87.25,72.66 85.61,72.66 PU201.7 ; PC212.1 84.89,70.77 84.43,70.32 82.67,70.32 81.94,71.04 v2(81.94,71.46)
  IN1 w0.081: v2(80.98,71.46) v2(81.94,71.46)
N64625485: length 3.2
  TOP w0.127: PC213.1 87.48,66.77 v3(87.67,66.58) ; PC213.1 PR265.2 ; PC213.1 87.55,67.9 88.43,67.9 PQ218.2
N64625491: length 2.3
  TOP w0.127: v3(91.34,66.63) PR274.1 90.33,67.9 PQ218.5
N64625687: length 6.9
  TOP w0.127: 85.61,73.31 PU201.6 ; 85.61,73.31 86.23,73.31 86.48,73.55 86.48,74.35 v3(85.46,75.37) ; 85.61,73.31 85.39,73.31 84.38,72.3 PR269.1 83.08,70.93 PR254.2
N64926554: length 1.6
  TOP w0.127: v1(158.09,60.59) 158.2,60.49 R10.2 CC225.1
N65247919:
  vias: v1(36.09,36.42)
N65247927: length 2.8
  TOP w0.127: v1(31.85,33.47) 32.3,33.92 R80.2
  TOP w0.254: R80.2 33.1,33.61 33.86,33.61 QE14.3
N65482285: length 1.6
  TOP w0.127: R9.2 141.4,56.84 141.53,56.72 v1(142,56.72)
  TOP w0.356: R9.2 CC125.1
N66101052: length 3.1
  BOTTOM w0.127: v2(88.11,27.67) PR1531.2
  BOTTOM w0.254: PU1501.5 86.9,27.59 87.22,27.26 PR1530.1 PR1531.2
N66101097: length 4.2
  TOP w0.127: v2(90.15,36.51) 91.39,36.51 v3(91.44,36.46)
  TOP w0.254: v2(90.15,36.51) 90.15,36.28 89.71,35.85 PR1506.2
  BOTTOM w0.254: PR1506.2 89.51,35.87 v2(90.15,36.51) 90.06,36.59 PU1500.5
N66101098: length 4.6
  TOP w0.127: v2(89.46,36.53) 89.46,36.92 v3(90.25,37.7)
  TOP w0.254: v2(89.46,36.53) 89.28,36.53 88.62,35.87 PR1510.1
  BOTTOM w0.127: PU1500.6 89.56,37.36
  BOTTOM w0.254: PR1510.1 88.62,35.87 89.28,36.53 v2(89.46,36.53) 89.56,36.63 89.56,37.36
N66101114: length 3.8
  TOP w0.127: PR1500.2 v3(91.3,41.02)
  TOP w0.203: PR1500.2 PR1522.2 89.06,41.47 89.06,41.28 v2(89.04,41.26)
  BOTTOM w0.203: v2(89.04,41.26) 89.06,41.24 PU1500.14
N66101116: length 3.1
  TOP w0.254: v2(85.76,32.18) 86.09,32.51 PR1511.2 PR1523.2
  BOTTOM w0.127: v2(85.76,32.18) 85.76,32.57 v1(85.92,32.72)
  BOTTOM w0.254: PU1501.14 85.9,32.04 v2(85.76,32.18)
N66101117: length 7.7
  TOP w0.254: v2(81.13,28.61) 81.23,28.61 81.61,28.23 81.61,27.19 v3(81.14,26.72) 81.14,26.72 v2(80.38,25.96)
  BOTTOM w0.203: v2(80.38,25.96) 80.38,25.93 80.47,25.84 80.47,25.83 80.76,25.54 PR1525.2 81.51,26.04 81.51,26.25 81.71,26.45 PR1524.1 82.04,26.45 82.27,26.22 82.27,26.04 PR1514.1
  BOTTOM w0.254: v2(81.13,28.61) 81.18,28.66 PR1515.1
N66101130: length 2.2
  BOTTOM w0.254: PR1531.1 89.33,26.04 PR1519.2 89.51,25.87 PR1520.1
N66101133: length 3.8
  BOTTOM w0.203: PR1530.2 86.74,26.04 PR1521.1 PR1527.1
  BOTTOM w0.254: PU1501.6 86.4,27.34 v2(86.34,27.27) PR1521.1
N66491485: length 4.7
  BOTTOM w0.127: v1(193.3,73.7) 193.29,73.7 RC64.2 192.38,75.73 RC66.2 192.28,75.99 193.34,77.05 JSPI1.16
N119009545: length 2
  TOP w0.127: PQ209.6 21.07,70.56 21.13,70.49 PR212.2 v1(22.17,70.06)
N119009632: length 0.7
  TOP w0.254: PR209.1 31.24,75.1 v2(30.89,74.75)
  vias: v1(29.36,74.88)
N119967293: length 13
  TOP w0.127: v2(51.11,67.12) 51.48,66.74 51.98,66.74 PQ216.3 ; v2(47.45,71.44) 47.23,71.44 46.74,70.95 46.05,70.95 45.62,71.38 PR244.2 44.93,73.87 v1(44.39,74.41)
  BOTTOM w0.127: v2(47.45,71.44) 47.45,70.77 v2(51.11,67.12)
N119982384: length 2.4
  BOTTOM w0.127: v1(60.55,62.76) 60.81,62.51 PR214.2 60.32,61.21 PU200.6
N122715521: length 2.6
  TOP w0.127: PQ209.3 19.42,72.92 PR211.2 18.58,72.08 v1(18.58,71.07)
N122716790: length 3.8
  TOP w0.127: v2(56.05,65.36) 56.14,65.46 v1(56.63,65.46) 56.82,65.27 PR242.2
  BOTTOM w0.127: PQ224.1 56.39,66.92 56.39,66.05 56.05,65.71 v2(56.05,65.36)
N122717029: length 23.8
  TOP w0.127: PQ213.1 54.38,60.64 v2(54.23,60.49)
  IN4 w0.081: v2(54.65,74.44) 53.48,73.27 53.48,70 54,69.48 54,66.93 54.61,66.32 54.61,60.87 v2(54.23,60.49)
  BOTTOM w0.127: v2(54.65,74.44) 54.65,77.17 53.42,78.4 v3(51.68,78.4) 51.36,78.72 PR239.1
N122717329: length 7.8
  TOP w0.127: PQ216.4 53.7,66.75 52.76,67.69 52.76,68.31 52.1,68.97 52.1,69.61 53.09,70.6 53.09,71.18 53.38,71.47 PQ217.3 53.76,72.18 v3(53.34,72.59)
N122717720: length 3.8
  TOP w0.127: PQ217.6 51.62,70.17 51.24,70.56 50.36,70.56 49.89,71.02 v1(49.89,71.45) 49.42,71.92 PR245.2
N122719403: length 21.4
  TOP w0.127: PQ215.6 59.43,62.95 60.25,63.77 60.25,65.06 60,65.31 60,66.47 59.77,66.7 59.19,66.7 58.77,67.12 58.77,68.17 58.21,68.72 57.71,68.72 56.77,69.66 56.77,71.48 55.58,72.67 v1(54.95,72.67) 54.67,72.67 53.32,74.02 53.32,75.33 51.98,76.67 v2(51.98,76.98)
  BOTTOM w0.127: v2(51.98,76.98) 51.98,76.92 51.41,76.35 PR241.2
N122723381: length 5.1
  TOP w0.127: PU201.2 89.85,72.66 91.27,72.66 PR230.1 PR224.2 91.83,74.11 92.75,74.11 93.27,74.63 v3(93.59,74.63)
N122728402: length 3.9
  TOP w0.127: v1(62.08,46.14) 62.96,47.02 PQ208.1 63.27,47.57 63.48,47.77 63.48,48.73 63.33,48.87 PQ208.3
N122733349: length 5.8
  TOP w0.127: v3(63.09,13.42) 63.65,13.42 PR266.2 PR270.1 PR262.1 63.45,15.58 63.2,15.33 PC214.1 62.42,15.34 62.42,16.51 PU203.5
N122733365: length 7
  TOP w0.127: v3(60.99,13.67) 60.99,16.34 61.81,17.16 PU203.6 63.1,17.16 63.3,17.36 PR271.1 PR259.2
N122733968: length 2.4
  TOP w0.127: PQ219.6 62.44,22.63 PR257.2 62,22.74 61.7,22.44 v3(61.06,22.44)
N122734452: length 4.9
  TOP w0.127: PU203.2 57.91,17.81 57.58,17.81 57.25,17.48 PR273.1 PR260.2 56.31,17.99 55.35,17.99 v3(54.98,17.63)
N122772225: length 3.3
  TOP w0.127: PR209.2 33.23,74.27 34.65,74.27 34.87,74.04 PQ207.6
N122777610: length 5.6
  TOP w0.127: PQ217.2 53.81,70.77 PR250.2 54.71,71.13 54.33,71.51 54.33,72.28 52.65,73.97 v3(52.65,74.5)
N122777613: length 5.5
  TOP w0.127: v2(57.35,65.48) 57.02,65.81 54.98,65.81 PR249.2
  BOTTOM w0.127: v1(57.8,66.96) 56.73,65.9 PQ224.2 57.2,65.33 v2(57.35,65.48)
N123360127: length 4.1
  TOP w0.127: UT1.H19 v2(40.23,64.09) ; v2(39.76,66.69) 39.76,67.04 39.64,67.15 RT12.1
  IN4 w0.081: v2(40.23,64.09) 40.23,64.1 40.23,64.27 39.64,64.86 39.64,66.57 v2(39.76,66.69)
N123360144: length 5.2
  TOP w0.127: v2(46.08,63.44) 46.4,63.12 UT1.Y18 ; v2(48.57,65.74) 48.95,66.13 RT5.1
  BOTTOM w0.127: v2(46.08,63.44) 46.44,63.44 47.8,64.8 48.03,64.8 48.57,65.34 v2(48.57,65.74)
N123760602: length 14.7
  TOP w0.127: PQ206.3 54.82,57.87 55.16,58.2 55.46,58.2 55.87,58.61 56.27,58.61 v2(56.34,58.67)
  IN1 w0.081: v2(60.7,65.56) 59.38,64.23 59.38,63.38 56.34,60.34 v2(56.34,58.67)
  BOTTOM w0.127: PR240.1 63.14,65.21 PU202.4 61.93,65.55 PR246.1 60.95,65.56 v2(60.7,65.56)
N123959194: length 4.5
  BOTTOM w0.127: v1(56.54,57.54) 56.54,57.79 PR225.1 57.98,59.23 57.98,60.17 58.51,60.7 58.51,61.2 PU200.4

## Copper pours and planes (outline as drawn)
+0.6VS on TOP (solid shape): 163.81,28.66 163.81,27.14 163.55,26.88 163.17,26.88 163.04,27.01 163.04,28.66 163.17,28.79 163.68,28.79
+0.6VS on TOP (solid shape): outline of 313 points within 94.84,17.36 160.44,19.77
+0.6VSP on TOP (solid shape): 167.29,30.92 168.23,30.92 168.3,30.85 168.3,30.29 168.23,30.22 167.4,30.22 167.23,30.06 167.23,29.17 165.2,27.14 164.06,27.14 163.98,27.22 163.98,27.51 164.54,27.51 164.54,28.02 163.98,28.02 163.98,28.55 164.24,28.81 165.69,28.81 166.32,29.43 166.32,31.25 166.33,31.27 166.86,31.27 166.86,31.27 166.94,31.27
+1.0V_CLK on TOP (solid shape): 142.47,70.18 142.29,69.92 142.39,69.62 142.42,69.54 142.38,69.46 142.24,69.15 142.44,68.86 142.47,68.85 142.47,68.31 142.44,68.3 142.25,68.1 142.26,67.82 142.34,67.72 142.42,67.66 142.47,67.61 142.47,66.91 142.44,66.84 142.37,66.81 142.06,66.63 142.06,66.28 142.08,66.24 141.84,66.01 141.81,66.01 141.47,65.92 141.38,65.58 141.39,65.55 141.2,65.36 140.95,65.36 140.18,66.13 140.18,66.51 140.44,66.76 141.33,66.76 141.83,67.27 141.83,67.61 142.03,67.88 141.93,68.19 141.9,68.26 141.93,68.34 142.04,68.57 141.96,68.82 141.93,68.89 141.96,68.95 142.04,69.19 141.94,69.43 141.91,69.5 141.94,69.57 142.03,69.88 141.83,70.14 141.83,70.32 142.03,70.51 142.09,70.56 142.13,70.62 142.34,70.82 142.47,70.82
+1.0V_CLK on IN2 (solid shape): 141.96,66.89 141.96,66.13 141.84,66.01 141.81,66.01 141.47,65.92 141.38,65.58 141.39,65.55 141.33,65.49 140.31,65.49 140.18,65.62 140.18,67.01 140.31,67.14 141.71,67.14
+1.0V_MPHYAON on IN2 (solid shape): outline of 138 points within 142.09,65.9 152.63,67.42
+1.0V_MPHYGT on TOP (solid shape): 143.97,65.87 144.05,65.83 144.06,65.74 144.41,65.29 144.75,65.74 144.74,65.77 144.8,65.83 144.86,65.76 144.87,65.75 144.95,65.63 145.07,65.55 145.08,65.55 145.26,65.36 145.26,64.47 144.63,63.84 143.1,63.84 142.72,64.22 142.72,65.17 142.77,65.25 142.86,65.26 143.24,65.34 143.32,65.73 143.33,65.83 143.41,65.87
+1.0V_MPHYGT on TOP (solid shape): outline of 82 points within 144.63,75.52 151.87,80.48
+1.0V_MPHYGT on IN1 (solid shape): outline of 1843 points within 142.22,62.35 153.51,78.32
+1.0V_MPHYGT on VCC: 143.08,63.33 141.96,64.45 141.96,66.4 142.85,67.29 142.85,71.48 144.12,72.75 144.12,75.8 146.51,78.19 148.08,78.19 148.44,77.83 148.44,77.41 145.64,74.61 145.64,71.31 144.25,69.91 144.25,67.8 145.01,67.04 145.01,63.94 144.4,63.33
+1.0V_PRIM_CORE on TOP (solid shape): 142.6,77.17 142.6,75.4 143.1,74.89 143.1,73.62 142.85,73.36 142.34,73.36 141.96,73.75 141.96,74.13 140.69,75.4 140.69,77.17 140.82,77.3 142.47,77.3
+1.0V_PRIM_CORE on TOP (solid shape): 193.02,71.19 193.02,70.57 193.02,70.56 193.02,70.21 192.52,70.21 192.52,69.7 193.02,69.7 193.02,69.41 192.52,69.41 192.52,68.9 193.02,68.9 193.02,67.78 192.89,67.65 192.09,67.65 191.16,68.58 191.16,71.23 191.26,71.33 192.87,71.33
+1.0V_PRIM_CORE on BOTTOM (solid shape): 192.18,71.1 192.59,71.1 192.97,70.72 192.97,67.96 192.74,67.74 191.91,67.74 191.62,68.03 191.62,71.06 191.66,71.11 192.18,71.11
+1.0V_PRIM_CORE on IN1 (solid shape): outline of 215 points within 139.93,59.52 142.47,63.59
+1.0V_PRIM_CORE on IN3 (solid shape): outline of 1921 points within 135.36,58.63 143.87,74.6
+1.0V_PRIM_CORE on VCC: 140.8,59.52 139.8,60.52 139.8,66.91 140.44,67.54 140.44,80.73 192.89,80.73 192.89,67.65 181.56,67.65 173.82,75.4 161.75,75.4 158.7,78.44 154.68,78.44 151.99,75.76 151.99,62.42 149.48,59.9 142.36,59.9 141.98,59.52 ; 1 cut-out
+1.0V_PRIM_COREP on TOP (solid shape): 195.08,76.41 195.41,76.2 195.73,76.41 196.03,76.41 196.34,76.24 196.64,76.41 197.46,76.41 198.35,75.52 198.87,75.52 198.92,75.47 198.92,75.34 198.85,75.27 197.71,75.27 196.78,74.34 196.71,74.31 196.63,74.35 196.35,74.48 196.07,74.34 195.99,74.3 195.91,74.35 195.59,74.48 195.31,74.28 195.29,74.25 195.14,74.25 194.72,74.31 194.55,73.92 194.56,73.89 194.41,73.75 194.41,71.59 194.67,71.33 194.67,69.86 194.87,69.66 194.87,68.39 194.77,68.28 193.38,68.28 193.17,68.49 193.17,69.01 193.15,69.03 192.65,69.03 192.65,69.28 193.15,69.28 193.17,69.3 193.17,69.81 193.15,69.83 192.65,69.83 192.65,70.08 193.15,70.08 193.17,70.1 193.17,71.37 193.27,71.47 193.27,75.95 193.51,76.2 193.94,76.2 193.95,76.16 194.36,75.9 194.65,76.3 194.67,76.38 194.75,76.41
+1.0V_VCCST on TOP (solid shape): 152.25,76.44 152.25,73.75 151.99,73.49 150.98,73.49 150.72,73.75 150.72,76.56 150.93,76.77 151.92,76.77
+1.0V_VCCST on IN4 (solid shape): outline of 152 points within 124.56,67.78 125.83,70.57
+1.0V_VCCSTG on TOP (solid shape): 161.52,69.22 161.52,68.13 161.34,67.95 161.34,67.88 161.34,67.12 161.04,66.81 161.04,65.92 160.99,65.87 160.33,65.87 160.25,65.95 160.25,68.01 160.25,68.02 160.29,68.17 160.25,68.32 160.25,68.33 160.25,68.92 160.6,69.27 161.47,69.27
+1.0V_VCCSTG on BOTTOM (solid shape): 119.99,78.44 119.99,77.3 119.74,77.05 119.1,77.05 118.72,77.43 117.83,77.43 117.2,78.06 117.2,78.22 118.75,78.22 118.75,78.16 118.75,78.11 118.77,78.06 118.79,78.01 118.82,77.97 118.86,77.93 118.9,77.9 118.95,77.87 119,77.85 119.05,77.84 119.1,77.83 119.15,77.84 119.21,77.85 119.26,77.87 119.3,77.9 119.34,77.93 119.38,77.97 119.41,78.01 119.43,78.06 119.45,78.11 119.46,78.16 119.46,78.22 119.45,78.27 119.43,78.32 119.41,78.37 119.38,78.41 119.34,78.45 119.3,78.48 119.26,78.51 119.21,78.53 119.15,78.54 119.1,78.55 119.05,78.54 119,78.53 118.95,78.51 118.9,78.48 118.86,78.45 118.82,78.41 118.79,78.37 118.77,78.32 118.75,78.27 118.75,78.22 117.2,78.22 117.2,78.44 117.45,78.7 119.74,78.7
+1.0VA on TOP (solid shape): 165.71,67.9 165.71,67.01 165.96,66.76 166.35,66.76 166.42,66.68 166.42,66.66 166.58,66.36 166.93,66.34 166.94,66.34 167.44,66.34 167.48,66.38 167.87,66.38 168,66.25 168,65.74 167.79,65.54 167.71,65.51 167.64,65.56 167.2,65.67 167,65.26 166.91,65.17 166.42,65.17 166.09,65.49 164.06,65.49 163.93,65.62 163.93,67.9 164.06,68.03 165.58,68.03
+1.0VA on TOP (solid shape): outline of 129 points within 152.6,74 158.98,80.6
+1.0VA on BOTTOM (solid shape): 192,57.23 192.13,57.23 192.2,57.17 192.2,56.78 191.63,56.78 191.63,56.22 192.2,56.22 192.2,55.97 191.65,55.97 191.65,55.41 192.2,55.41 192.2,55.13 192.2,55.13 192.2,54.33 192.06,54.19 191.78,54.19 191.76,54.2 191.48,54.31 191.21,54.19 190.67,54.19 190.48,54.38 190.48,56.98 190.73,57.24 192,57.24
+1.0VA on IN4 (solid shape): outline of 1357 points within 136.5,56.09 146.66,64.09
+1.0VA on VCC: 169.88,53.81 169.65,54.04 169.65,63.33 152.5,63.33 152.5,75.54 154.89,77.94 158.49,77.94 161.54,74.89 173.61,74.89 181.35,67.14 192.89,67.14 192.89,55.31 191.39,53.81
+1.0VAP on TOP (solid shape): 196.95,56.98 196.95,54.82 196.83,54.7 196.44,54.7 196.19,54.95 194.16,54.95 194.07,55.04 194.07,57.87 196.06,57.87
+1.0VAP on BOTTOM (solid shape): 197.21,56.73 200.13,56.73 200.23,56.63 200.23,53.91 200,53.68 197.46,53.68 196.19,54.95 192.46,54.95 192.33,55.08 192.33,55.18 192.33,55.18 192.33,55.54 191.83,55.54 191.8,55.57 191.8,55.84 192.33,55.84 192.33,56.34 191.8,56.34 191.8,56.64 192.33,56.64 192.33,57.15 192.41,57.24 193.4,57.24 194.03,57.87 196.06,57.87
+1.0VS_VCCIO on TOP (solid shape): 167.71,55.96 167.76,55.91 167.76,55.9 168.07,55.43 168.45,55.85 168.47,55.93 168.55,55.97 169.36,55.97 169.43,55.89 169.43,55.61 169.45,55.08 169.97,55.16 170.18,55.16 170.54,54.81 170.54,54.38 170.39,54.24 169.96,54.24 169.92,54.24 169.92,54.27 169.92,54.77 169.41,54.77 169.41,54.24 169.12,54.24 169.12,54.77 168.61,54.77 168.61,54.24 168.59,54.24 168.57,54.22 168.14,54.22 168.14,54.19 167.62,54.19 166.35,55.46 166.35,55.69 166.4,55.74 167.11,55.74 167.34,55.97 167.71,55.97
+1.0VS_VCCIO on TOP (solid shape): 137.38,58.77 137.38,58.33 137.39,58.33 137.39,58.22 137.38,58.2 137.32,57.82 137.65,57.62 137.69,57.6 137.7,57.56 137.7,56.79 137.64,56.73 136.89,56.73 136.89,56.78 136.86,56.78 136.86,56.96 136.47,57.35 136.46,57.36 136.36,57.56 136.16,57.66 136.09,57.71 136.09,57.81 136.11,57.84 136.13,57.88 136.17,57.92 136.22,57.88 136.91,57.98 136.25,58.2 136.17,58.15 136.08,58.2 135.49,58.19 135.74,57.64 135.81,57.59 135.81,57.49 135.79,57.16 136.05,56.95 136.07,56.95 136.09,56.94 136.26,56.76 136.26,56.08 135.98,56.08 135.33,55.43 134.2,55.43 134.09,55.54 134.09,56.16 134.23,56.29 134.65,56.29 134.65,56.52 134.72,56.6 134.72,57.08 134.79,57.14 134.79,57.47 134.72,57.54 134.72,57.54 134.72,58.12 134.6,58.25 133.96,58.25 133.83,58.38 133.83,58.89 133.96,59.01 137.06,59.01 137.14,59.01
+1.0VS_VCCIO on BOTTOM (solid shape): 135.75,57.32 135.76,57.3 135.79,57.15 135.89,57.03 135.89,55.94 135.38,55.43 135.08,55.43 135.07,55.47 134.9,55.65 134.66,55.6 134.47,55.43 134.26,55.43 134.14,55.56 134.14,55.94 134.16,55.99 134.17,56.04 134.39,56.27 134.41,56.27 134.55,56.35 134.62,56.48 134.62,56.5 134.67,56.55 134.67,57.03 134.7,57.09 135.08,57.46 135.61,57.46
+1.0VS_VCCIO on IN1 (solid shape): outline of 345 points within 125.58,55.36 135.87,58.12
+1.0VS_VCCIO on IN3 (solid shape): outline of 526 points within 126.98,54.7 136.75,58.12
+1.0VS_VCCIO on IN4 (solid shape): outline of 612 points within 127.1,55.33 135.74,60.03
+1.0VS_VCCIO on VCC: 146.26,50.12 145.11,51.27 143.46,51.27 142.34,52.39 142.34,52.51 142.28,52.58 142.28,54.65 141.41,55.52 138.58,55.52 137.95,54.89 128.83,54.89 128.56,55.16 128.56,55.92 127.82,56.66 127.23,56.66 127.23,58.12 128.39,58.12 130.17,56.35 133.68,56.35 135.1,57.76 135.1,62.82 139.29,62.82 139.29,60.3 140.59,59.01 142.19,59.01 142.57,59.39 149.69,59.39 152.5,62.21 152.5,62.82 169.14,62.82 169.14,52.51 166.75,50.12
+1.0VS_VCCIOP on TOP (solid shape): 169.79,54.22 169.79,54.22 169.79,54.09 170.34,54.09 170.43,53.99 170.43,53.04 170.43,52.81 169.95,52.33 169.95,52.14 169.95,51.63 170.19,51.39 172.7,51.39 173.37,50.72 173.37,50.55 173.31,50.49 172.62,50.49 172.6,50.5 171.17,50.5 170.79,50.12 168.3,50.12 168.07,50.2 167.84,50.12 167.49,50.12 167.36,50.25 167.36,51.27 167.49,51.39 167.74,51.39 168.12,51.77 168.12,53.96 168.23,54.06 168.27,54.06 168.27,54.09 168.74,54.09 168.74,54.58 168.81,54.64 168.99,54.64 168.99,54.11 168.99,54.09 169.54,54.09 169.54,54.11 169.54,54.64 169.79,54.64
+1.2V_DDR on TOP (solid shape): 161.77,24.34 161.77,24.22 162.41,23.58 162.41,22.01 161.91,22.01 161.91,21.27 162.41,21.27 162.41,20.82 161.92,20.82 161.92,20.05 162.41,20.05 162.41,18.75 162.15,18.5 160.88,18.5 160.63,18.75 160.63,24.09 161.01,24.47 161.65,24.47
+1.2V_DDR on TOP (solid shape): 164.31,48.98 164.31,47.96 164.57,47.71 165.2,47.71 165.33,47.58 166.09,47.58 166.35,47.33 166.35,46.31 166.22,46.19 164.57,46.19 164.19,46.57 162.66,46.57 162.54,46.69 162.54,48.14 162.54,48.98 162.66,49.11 164.19,49.11
+1.2V_DDR on TOP (solid shape): outline of 92 points within 96.88,25.74 102.46,30.06
+1.2V_DDR on TOP (solid shape): outline of 92 points within 143.36,25.74 151.34,30.18
+1.2V_DDR on TOP (solid shape): outline of 471 points within 152.38,25.99 158.34,38.82
+1.2V_DDR on TOP (solid shape): outline of 741 points within 122.15,46.95 139.68,53.43
+1.2V_DDR on TOP (solid shape): outline of 1634 points within 106.27,22.18 149.2,39.2
+1.2V_DDR on BOTTOM (solid shape): outline of 203 points within 147.17,31.71 150.72,34.63
+1.2V_DDR on BOTTOM (solid shape): outline of 246 points within 121.77,31.26 133.96,35.07
+1.2V_DDR on BOTTOM (solid shape): outline of 392 points within 106.4,31.58 111.61,37.17
+1.2V_DDR on BOTTOM (solid shape): outline of 839 points within 154.66,18.75 162.92,34.63
+1.2V_DDR on IN1 (solid shape): outline of 1109 points within 130.91,21.61 144.12,31.45
+1.2V_DDR on IN1 (solid shape): outline of 1644 points within 98.02,23.58 111.86,33.61
+1.2V_DDR on IN2 (solid shape): 154.53,29.74 154.53,29.23 154.79,28.98 155.11,28.98 155.23,28.86 155.23,28.59 155.04,28.41 154.71,28.41 154.63,28.45 154.62,28.55 154.11,29 154.29,28.35 154.33,28.33 154.34,28.29 154.34,28.16 154.31,28.12 154.31,27.77 154.34,27.74 154.34,27.64 154.53,27.45 154.53,26.95 154.41,26.82 154.03,26.82 153.94,26.91 153.94,27.82 153.9,27.86 153.9,28.09 153.33,28.66 153.33,30.5 153.39,30.57 153.71,30.57
+1.2V_DDR on IN2 (solid shape): 144.5,32.34 144.5,30.82 144.25,30.57 144.25,30.18 144.28,30.02 144.37,29.89 144.37,29.68 144.25,29.55 144,29.55 143.92,29.63 142.77,29.63 142.22,30.18 142.22,30.83 142.24,30.85 142.31,30.87 142.63,30.75 142.88,30.85 142.95,30.88 143.02,30.85 143.3,30.75 143.55,30.88 143.63,30.92 143.71,30.88 144.34,31.12 143.7,31.34 143.63,31.3 143.55,31.33 143.5,31.38 143.45,31.41 143.4,31.5 143.63,31.9 143.4,32.3 143.45,32.39 143.61,32.58 143.61,32.84 143.62,32.93 143.7,32.98 143.87,32.98
+1.2V_DDR on IN2 (solid shape): 141.54,33.53 141.57,33.44 141.51,33.36 141.43,32.77 142,32.94 142.02,32.98 142.85,32.98 142.94,32.93 142.95,32.84 142.94,32.58 143.1,32.39 143.16,32.3 143.1,32.21 143.06,32.19 143.02,32.15 142.95,32.12 142.88,32.15 142.34,32.12 142.45,31.59 142.51,31.5 142.45,31.41 142.41,31.39 142.38,31.35 142.31,31.33 142.23,31.35 142.22,31.37 142.22,31.58 141.83,31.96 141.03,31.96 141.02,32 140.89,32.19 140.67,32.26 140.64,32.26 140.5,32.41 140.47,32.5 140.54,32.58 140.77,32.95 140.45,33.27 140.37,33.33 140.39,33.44 140.56,33.61 141.45,33.61
+1.2V_DDR on IN2 (solid shape): 121.01,29.68 120.98,29.65 120.98,29.3 121.01,29.27 121.01,29.09 120.95,29 120.85,29.01 120.32,28.75 120.76,28.36 120.79,28.37 120.85,28.31 120.82,28.28 120.82,28.15 120.78,28.11 120.78,27.79 120.82,27.75 120.82,27.64 120.94,27.52 121.26,27.52 121.51,27.26 121.51,27.01 121.01,26.5 121.01,26.47 121,26.46 120.96,26.3 121,26.14 121.01,26.13 121.01,25.89 120.95,25.8 120.85,25.81 120.36,25.68 120.49,25.19 120.55,25.1 120.49,25.01 120.36,24.52 120.85,24.4 120.95,24.4 121.01,24.31 121.01,24.22 121.14,24.08 121.14,23.92 121.1,23.91 120.94,23.32 121.53,23.47 121.61,23.54 121.7,23.52 121.77,23.45 121.77,22.95 121.64,22.82 121.05,22.82 120.53,23.35 120.5,23.42 120.53,23.49 120.52,24.01 120,23.98 119.93,23.94 119.86,23.97 119.36,24.47 119.36,25.9 119.37,25.93 119.4,25.95 119.52,25.98 119.62,26.05 119.69,26.08 119.76,26.05 120.37,26.3 119.76,26.55 119.69,26.52 119.62,26.55 119.44,26.65 119.24,26.63 119.15,26.64 119.1,26.73 119.1,27.26 119.61,27.77 119.61,27.88 119.65,27.92 119.65,29.62 119.83,29.8 120.88,29.8
+1.2V_DDR on IN2 (solid shape): outline of 852 points within 97.51,27.39 105.39,34.5
+1.2V_DDR on IN2 (solid shape): outline of 6873 points within 104.75,18.12 162.78,58.25
+1.2V_DDR on IN3 (solid shape): outline of 216 points within 97.89,30.82 102.46,47.46
+1.2V_DDR on IN4 (solid shape): outline of 2689 points within 138.28,21.04 162.28,29.55
+1.2V_DDRP on TOP (solid shape): 168.3,29.97 168.3,28.3 166.04,26.04 164.67,26.04 164.06,25.43 164.06,24.25 164.48,23.83 165.51,23.83 165.57,23.78 166.6,23.78 166.66,23.83 170.66,23.83 171.3,23.2 171.3,21.17 170.66,20.53 168.76,20.53 167.74,19.52 162.64,19.52 162.61,19.54 162.61,23.66 162.79,23.83 162.79,25.61 164.11,26.93 165.33,26.93 167.49,29.09 167.49,29.93 167.58,30.02 168.24,30.02
+1.8VA on TOP (solid shape): 168.76,70.57 168.76,69.55 168.63,69.43 167.62,69.43 167.49,69.55 167.49,70.57 167.62,70.7 168.63,70.7
+1.8VA on TOP (solid shape): 30.5,43.25 30.66,43.27 32.36,43.27 32.49,43.14 32.49,42.63 32.36,42.5 31.34,42.5 31.22,42.38 29.54,42.38 29.39,42.53 29.39,43.14 29.52,43.27 30.34,43.27
+1.8VAP on TOP (solid shape): 168.89,76.54 168.89,74.51 168.69,74.23 168.79,73.91 168.89,73.82 168.89,73.29 168.74,73.15 168.67,72.71 169.08,72.51 169.1,72.51 169.27,72.35 169.27,71.33 168.78,70.85 168.34,70.85 168.34,71.41 167.91,71.41 167.91,70.85 167.46,70.85 167.23,71.08 167.23,76.48 167.47,76.71 168.71,76.71
+1.8VS_AUDIO on TOP (solid shape): 30.2,39.75 31.18,39.75 31.22,39.71 31.22,38.71 31.19,38.64 31.12,38.61 30.88,38.5 30.79,38.25 30.77,38.17 30.69,38.13 29.03,38.13 28.93,38.24 28.93,38.89 28.83,38.98 28.3,38.98 28.16,39.13 28.16,39.65 28.35,39.84 30.11,39.84
+1.8VU on TOP (solid shape): 161.01,42.5 161.01,41.11 160.76,40.85 160.19,40.85 160.12,40.92 160.12,42.5 160.25,42.63 160.88,42.63
+1.8VU on TOP (solid shape): 161.01,28.41 162.03,28.41 162.15,28.28 162.15,27.64 162.03,27.52 160.25,27.52 159.61,26.88 159.61,26.25 159.87,25.99 159.87,25.23 159.68,25.04 159.68,25.04 159.49,24.85 159.11,24.85 158.98,24.98 158.98,25.74 158.79,25.92 158.79,25.94 158.74,26.07 158.63,26.15 158.6,26.16 158.6,26.34 158.77,26.52 158.77,26.55 158.85,26.63 158.85,26.76 158.6,27.01 158.6,27.14 158.77,27.32 158.77,27.4 158.79,27.46 159.11,27.77 159.36,27.77 160,28.41 160,28.53 160.12,28.66 160.76,28.66
+1.8VU on BOTTOM (solid shape): outline of 6402 points within 98.02,24.72 160.93,31.71
+1.8VUP on TOP (solid shape): 163.93,44.92 163.93,43.01 163.81,42.88 163.04,42.88 162.79,42.63 162.79,42.22 162.75,42.22 162.47,41.87 162.75,41.52 162.79,41.51 162.79,41.11 162.41,40.73 161.77,40.73 161.19,41.31 161.19,41.78 161.72,41.78 161.72,42.21 161.19,42.21 161.19,42.68 161.52,43.01 161.52,43.89 161.52,43.9 161.54,44.03 161.52,44.16 161.52,44.17 161.52,44.79 161.76,45.03 161.83,45.03 161.89,45.04 163.81,45.04
+3.3VDX_SSD on TOP (solid shape): 176.89,31.84 176.89,30.35 176.73,30.2 176.45,30.2 176.38,30.12 176.38,28.72 176.39,28.72 176.51,28.61 176.81,28.61 177.14,28.28 177.14,23.58 177.01,23.45 174.98,23.45 174.85,23.58 174.85,28.81 175.02,28.97 175.02,29.91 174.85,30.08 174.85,31.96 174.98,32.09 176.63,32.09
+3.3VDX_SSD on TOP (solid shape): 178.03,40.28 178.03,39.33 178.28,39.07 178.28,38.57 178.1,38.26 178.28,37.95 178.28,37.8 178.03,37.55 178.03,37.02 178.03,37 178.03,36.28 177.94,36.14 177.93,35.97 177.93,35.95 177.89,35.9 177.25,35.9 176.95,36.2 175.87,36.2 175.74,36.32 175.74,36.66 175.87,36.79 176.51,36.79 176.63,36.92 176.63,37.77 176.85,37.99 176.96,38.23 176.89,38.48 176.89,38.49 176.89,38.57 176.63,38.82 176,38.82 175.74,39.07 175.74,41.74 175.87,41.87 176.44,41.87
+3.3VDX_SSD on BOTTOM (solid shape): outline of 170 points within 173.08,35.9 178.16,41.7
+3.3VDX_SSD on BOTTOM (solid shape): outline of 208 points within 173.36,23.33 177.78,27.7
+3.3VDX_SSD on IN2 (solid shape): outline of 480 points within 175.83,23.2 179.3,37.93
+3V_LDO on BOTTOM (solid shape): 63.32,67.77 63.32,67.23 63.2,67.11 63.04,67.11 63,67.07 62.91,67.07 62.69,66.85 62.69,66.73 62.52,66.57 62.18,66.48 62.09,66.13 61.87,65.91 60.72,65.91 60.5,66.13 60.5,66.49 60.78,66.77 61.21,66.77 61.76,66.93 62.04,67.43 62.04,67.52 62.04,67.6 62.03,67.65 62.02,67.7 62.16,67.85 63.24,67.85
+3V_PCH on TOP (solid shape): 182.35,28.36 182.35,26.12 182.23,26.01 181.25,26.01 181.19,26.07 181.19,26.34 181.33,26.48 181.33,27.26 181.2,27.39 180.57,27.39 180.44,27.52 180.44,28.34 180.58,28.48 182.22,28.48
+3V_PCH on TOP (solid shape): 180.26,45.73 180.26,45.53 180.27,45.53 180.27,45.34 180.27,45.34 180.27,43.98 180.06,43.77 179.05,43.77 178.66,44.15 178.17,44.15 177.98,44.34 176.76,44.34 176.57,44.15 175.87,44.15 175.27,43.56 173.93,43.56 173.85,43.65 173.85,43.91 173.84,43.92 173.84,44.03 175.11,45.3 177.14,45.3 177.9,46.06 179.94,46.06
+3V_PCH on IN1 (solid shape): 157.58,50.25 157.58,49.17 157.54,49.09 157.45,49.07 156.98,48.74 157.45,48.4 157.54,48.38 157.58,48.3 157.58,47.47 157.47,47.35 157.43,47.2 157.43,47.18 157.33,47.08 156.03,47.08 155.68,47.43 155.68,50.12 156.06,50.5 157.33,50.5
+3V_PCH on IN1 (solid shape): outline of 534 points within 138.66,55.97 147.04,58.51
+3V_PCH on IN2 (solid shape): outline of 2130 points within 137.52,53.93 152.88,64.73
+3V_PCH on IN3 (solid shape): 160.1,69.93 160.1,69.39 159.25,68.54 159.24,68.54 159,68.28 159.11,67.94 159.11,67.42 158.27,66.58 157.22,66.58 156.82,66.18 156.82,64.19 157.66,63.35 157.66,62.96 157.62,62.91 157.33,62.91 157.32,62.92 157.18,62.95 157.03,62.92 157.02,62.91 156.66,62.91 155.21,64.37 154.63,64.37 154.35,64.65 154.35,65.21 156.63,67.5 157.8,67.5 158.24,67.94 158.24,68.93 159.39,70.08 159.94,70.08
+3V_PCH on IN3 (solid shape): outline of 556 points within 159.11,40.63 174.6,48.47
+3V_PCH on IN3 (solid shape): outline of 608 points within 176.89,25.99 183.87,46.55
+3V_PCH on IN4 (solid shape): 149.87,77.94 149.94,77.9 149.97,77.82 150.32,77.42 150.68,77.82 150.7,77.9 150.78,77.94 152.27,77.94 152.51,77.7 153,77.7 153.01,77.68 153.01,77.17 152.76,76.92 148.07,76.92 148.06,76.92 147.8,77.17 147.8,77.27 147.83,77.31 147.88,77.31 148.32,77.34 148.39,77.78 148.39,77.89 148.48,77.94
+3V_PCH on IN4 (solid shape): outline of 351 points within 156.44,40.98 160.76,50.5
+3V_PCH_DSW on IN2 (solid shape): outline of 1318 points within 141.96,51.27 150.6,58.25
+3V_TBT on TOP (solid shape): 45.95,50.33 45.95,50.12 45.59,49.77 45.48,49.77 45.44,49.73 45.44,48.98 45.82,48.6 45.82,47.84 45.7,47.71 45.45,47.71 45.27,47.76 45.09,47.72 45.08,47.71 44.94,47.71 44.81,47.82 44.65,47.86 44.58,47.89 44.55,47.96 44.49,48.02 44.49,49.47 44.56,49.6 44.57,49.75 44.57,49.76 44.81,50 45.15,50 45.42,50.11 45.52,50.39 45.54,50.47 45.62,50.5 45.77,50.5
+3V_TBT on TOP (solid shape): 38.03,56.42 38.03,56.33 37.83,56.14 37.82,56.13 37.72,56.06 37.67,55.95 37.67,55.93 37.56,55.83 37.45,55.83 37.28,55.66 37.24,55.62 36.94,55.31 36.94,55.28 36.92,55.26 36.77,55.1 36.74,54.87 36.75,54.85 36.25,54.34 35.09,54.34 33.7,52.96 33.7,52.96 33.61,52.87 31.82,52.87 31.7,52.74 31.3,52.74 31.24,52.8 31.24,55.97 31.29,56.02 31.8,56.02 32.19,55.63 32.17,55.6 32.24,55.2 32.63,55.12 32.74,54.8 33.07,54.71 33.2,54.78 33.3,54.9 33.34,55.06 33.3,55.22 33.3,55.41 33.5,55.61 35.69,55.61 36.17,56.09 36.51,56.43 37.2,56.43 37.2,56.44 37.72,56.44 37.74,56.47 37.84,56.47 37.88,56.5 37.95,56.5
+3V_TBT on BOTTOM (solid shape): 25.54,50.03 25.54,49.46 25.22,49.15 25.22,47.57 25.11,47.46 24.24,47.46 24.23,47.47 24.23,47.6 24.2,47.75 24.12,47.87 24.12,48.49 24.18,48.69 24.12,48.88 24.12,49.81 24.41,50.1 25.48,50.1
+3V_TBT on IN1 (solid shape): outline of 743 points within 31.9,53.29 40.46,59.16
+3V_TBT on IN4 (solid shape): outline of 2394 points within 24.09,47 47.22,56.49
+3V_TBT_PWR on TOP (solid shape): 48.36,50.89 48.36,49.18 48.36,49.18 48.36,48.96 48.23,48.69 48.35,48.41 48.36,48.39 48.36,48.35 48.24,48.22 48.16,48.22 47.94,48 47.59,48 47.51,47.93 47.31,47.93 47.09,47.71 46.46,47.71 46.33,47.84 46.33,49.53 46.62,49.83 46.62,49.91 47.73,51.01 48.24,51.01
+3V_TBT_S0 on BOTTOM (solid shape): 24.62,52.93 24.62,52.26 25.55,51.33 25.55,50.51 25.48,50.43 24.48,50.43 24.21,50.16 23.33,50.16 23.26,50.23 23.26,52.78 23.49,53.02 24.54,53.02
+3V_TBT_S0 on IN4 (solid shape): outline of 1758 points within 24.01,51.31 44.95,61.42
+3V_VC on BOTTOM (solid shape): outline of 334 points within 55.08,16.09 67.03,20.41
+3VA_TBT on IN3 (solid shape): outline of 244 points within 39.35,51.65 46.58,53.3
+3VALW on TOP (solid shape): 26.39,70.1 26.39,69.36 26.23,69.2 25.04,69.2 24.8,69.44 24.8,70.06 24.96,70.21 26.28,70.21
+3VALW on TOP (solid shape): 182.35,34.25 182.35,33.23 182.22,33.11 180.44,33.11 180.38,33.17 180.38,33.93 180.82,34.38 182.22,34.38
+3VALW on TOP (solid shape): 174.35,15.45 174.35,14.69 174.22,14.56 172.95,14.56 172.82,14.69 172.82,15.58 172.45,15.95 172.06,15.95 172,16.01 172,16.65 172.07,16.72 173.08,16.72
+3VALW on TOP (solid shape): 174.73,34.38 174.73,33.99 174.47,33.74 173.89,33.74 173.79,33.74 173.79,33.77 173.18,33.77 173.08,33.87 173.08,34.5 173.1,34.53 174.57,34.53
+3VALW on TOP (solid shape): 36.25,41.79 36.25,41.16 36.17,41.08 36.17,41 36.14,40.97 36.14,40.31 36.17,40.28 36.17,39.58 36.04,39.46 35.15,39.46 35.03,39.58 35.03,41.77 35.13,41.87 36.17,41.87
+3VALW on TOP (solid shape): 170.6,16.66 170.6,16.01 170.43,15.83 169.01,15.83 168.86,15.68 168.73,15.68 168.73,15.58 168.38,15.58 168.25,15.71 168.25,15.96 168.89,16.6 169.39,16.6 169.52,16.72 170.54,16.72
+3VALW on TOP (solid shape): 170.66,66.63 170.66,62.57 170.54,62.44 170.28,62.44 170.28,62.45 169.85,62.45 169.7,62.6 169.7,62.91 170.23,62.91 170.23,63.35 169.7,63.35 169.7,64.04 169.39,64.35 169.39,66.35 169.41,66.37 169.41,66.5 169.44,66.55 169.71,66.82 170.47,66.82
