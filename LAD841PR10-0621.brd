# Allegro board LAD841PR10-0621.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on IN2 (solid shape): outline of 193 points within 0.65,0.42 217.56,81.75
GND on IN3 (solid shape): 7.98,54.95 12.93,54.95 15.85,52.03 16.32,52.03 16.59,51.76 16.59,51.6 15.75,50.76 11.72,50.76 11.72,52.11 11.4,52.54 10.89,52.36 0.9,52.36 0.73,52.44 0.65,52.61 0.65,56.85 6.07,56.85
GND on IN3 (solid shape): 16.59,36.49 1.25,36.49 1.25,37.71 1.33,37.88 1.5,37.96 2.31,37.96 10.78,37.96 10.87,37.94 10.96,37.88 11.1,37.79 11.27,37.76 11.59,37.89 11.72,38.21 11.72,38.74 11.73,38.74 11.73,39.57 16.59,39.57
GND on IN3 (solid shape): outline of 189 points within 0.65,0.43 217.56,81.75
GND on IN3 (solid shape): outline of 19020 points within 99.04,20.81 159.87,57.74
GND on IN4 (solid shape): 6.83,56.09 8.36,56.09 10.77,53.68 14.2,53.68 15.93,51.95 16.4,51.95 16.59,51.76 16.59,51.56 15.79,50.76 11.72,50.76 11.72,52.11 11.4,52.54 10.89,52.36 0.9,52.36 0.73,52.44 0.65,52.61 0.65,56.85 6.07,56.85
GND on IN4 (solid shape): 16.59,36.49 1.25,36.49 1.25,37.71 1.33,37.88 1.5,37.96 2.31,37.96 10.78,37.96 10.87,37.94 10.96,37.88 11.1,37.79 11.27,37.76 11.59,37.89 11.72,38.21 11.72,38.74 11.73,38.74 11.73,39.57 16.59,39.57
GND on IN4 (solid shape): outline of 186 points within 0.65,0.43 217.56,81.75
GND on IN4 (solid shape): outline of 3131 points within 4.76,55.79 37.44,67.89
GND on GND1: outline of 166 points within 0.26,0.26 217.56,81.75 ; 9 cut-outs
GND on GND2: outline of 166 points within 0.26,0.26 217.56,81.75 ; 7 cut-outs
GND on VCC: 26.77,54.34 27.79,53.32 27.79,36.89 27.68,36.79 25.02,36.79 24.76,36.53 5.7,36.53 5.7,36.94 10.53,36.94 12,36.94 12.74,38.21 12.74,52.11 12,53.38 10.53,53.38 1.67,53.38 1.67,65.72 2.49,65.72 2.96,65.77 3.41,65.92 4.55,66.42 4.55,58.02 8.63,53.93 20.78,53.93 22.07,55.22 22.07,60.11 22.37,60.46 22.07,60.82 22.07,62.16 22.37,62.52 22.07,62.89 22.07,65 24.21,67.14 27.43,67.14 27.79,66.78 27.79,57.34 26.77,56.32
GND on VCC: 103.46,20.91 99.67,24.7 99.67,32.96 98.53,34.1 98.53,34.99 97.13,36.39 97.13,55.1 102.32,60.28 109.47,60.28 113.79,55.97 117.17,55.97 117.24,56.03 125.02,56.03 125.28,56.28 127.66,56.28 128.18,55.76 128.18,55 128.67,54.5 138.1,54.5 138.74,55.14 141.25,55.14 141.31,55.07 141.42,54.76 141.73,54.65 141.9,54.49 141.9,52.58 141.83,52.51 141.83,52.18 143.25,50.76 144.9,50.76 146.05,49.62 166.96,49.62 169.65,52.3 169.65,53.07 169.88,53.3 183.1,53.3 183.35,53.2 183.6,53.3 191.6,53.3 193.4,55.1 193.4,80.73 198.73,80.73 199.05,80.9 199.41,80.95 199.92,80.95 200.28,80.9 200.61,80.73 204.93,80.73 204.93,42 201.42,42 198.12,38.69 188.06,38.69 187.8,38.78 187.55,38.69 174.88,38.69 171.04,34.86 171.04,24.07 170.05,23.07 160.02,23.07 157.86,20.91 ; 1 cut-out
GND on GND3: outline of 166 points within 0.26,0.26 217.56,81.75 ; 15 cut-outs
GNDA_CHG on TOP (solid shape): 41.5,33.49 41.5,32.22 41.17,31.89 41.13,31.89 41.12,31.88 41.12,31.43 41.14,31.41 41.54,31.41 41.54,30.87 41.98,30.87 41.98,31.41 42.41,31.41 42.42,31.4 42.77,31.4 42.99,31.18 42.99,28.13 42.24,27.38 39.95,27.38 39.85,27.48 39.85,29.72 39.97,29.97 39.85,30.21 39.85,31.07 40.74,31.96 40.74,32.03 40.75,32.04 40.79,32.22 40.74,32.4 40.74,32.79 40.35,33.19 40.35,33.21 40.25,33.43 40.03,33.53 40.01,33.53 39.95,33.59 39.88,33.59 39.76,33.71 39.77,33.73 39.67,34.07 39.34,34.16 39.31,34.16 39.19,34.27 38.2,34.27 38.08,34.15 38.08,33.61 37.95,33.49 37.38,33.49 37.19,33.68 37.19,34.38 37.57,34.76 40.23,34.76
VCC0V9_LVR_OUT on IN3 (solid shape): outline of 1388 points within 29.24,58 41.63,65.49
VCC0V9_SVR on TOP (solid shape): 34.01,52.53 34.01,49.19 33.69,48.87 31.44,48.87 31.22,49.09 31.22,52.48 31.29,52.55 31.88,52.55 32.05,52.72 33.82,52.72
VCC0V9_SVR on TOP (solid shape): 36.3,60.53 36.3,60.53 36.36,60.45 36.44,60.39 36.45,60.39 36.58,60.25 36.58,59.68 36.58,59.62 36.58,59.57 36.58,58.92 36.46,58.8 36.08,58.8 36,58.88 36,59.74 35.92,59.81 33.59,59.81 33.56,59.84 33.56,60.75 33.73,60.91 35.92,60.91
VCC0V9_SVR on BOTTOM (solid shape): outline of 1108 points within 31.85,49.21 42.52,63.64
VCC0V9_SVR on IN2 (solid shape): outline of 881 points within 35.06,58.25 42.39,63.84
VCC0V9_SVR on IN4 (solid shape): outline of 121 points within 35.41,58.89 42.45,63.46
VCC3V3_TBT_LDO on TOP (solid shape): 41.5,39.58 41.5,39.1 41.53,39.07 43.54,39.07 43.79,38.82 43.79,38.06 43.66,37.93 42.77,37.93 42.14,38.57 42.14,38.62 42.06,38.69 41.63,38.69 41.63,38.69 41.58,38.69 41.5,38.62 41.5,38.06 41.38,37.93 40.87,37.93 40.74,38.06 40.74,39.54 40.91,39.71 41.38,39.71
VIN_1V_PRIM on TOP (solid shape): 81.38,31.07 83.54,31.07 83.8,30.82 83.8,29.55 83.54,29.3 81.89,29.3 80.75,30.44 80.11,30.44 79.99,30.57 79.99,31.45 80.11,31.58 80.87,31.58
VIN_1V_PRIM on BOTTOM (solid shape): 85.05,30.82 85.05,29.55 84.98,29.49 80.51,29.49 80.45,29.56 80.36,29.62 80.33,29.63 80.33,30.73 80.67,31.07 84.8,31.07
VIN_PRIM on TOP (solid shape): 203.21,79.61 203.21,77.46 203.31,77.36 203.31,74.51 203.18,74.38 202.23,74.38 202.12,74.27 201.18,74.27 201.13,74.32 201.13,75.51 201.18,75.56 201.2,75.55 201.37,75.56 201.51,75.65 201.91,75.65 202.03,75.78 202.03,76.59 201.95,76.67 201.89,76.75 201.81,76.81 201.22,77.4 201.22,78.77 201.36,78.9 201.4,78.91 201.6,79.04 201.67,79.28 201.67,79.74 201.85,79.92 202.9,79.92
VIN_VCC_EDRAM on TOP (solid shape): 85.89,41.17 86.05,41.13 86.21,41.16 86.22,41.17 86.48,41.17 86.49,41.16 86.64,41.13 86.79,41.16 86.8,41.17 87.29,41.17 87.48,40.98 87.48,38.31 87.35,38.19 86.08,38.19 85.74,38.53 85.75,38.56 85.74,38.86 85.5,39.04 85.49,39.04 85.38,39.15 85.38,40.15 85.76,40.53 85.76,41.04 85.89,41.17
VIN_VCC_EDRAM on BOTTOM (solid shape): 88.21,40.38 88.21,38.59 88.15,38.53 85.99,38.53 85.77,38.75 85.77,38.76 85.75,38.83 85.71,38.9 85.7,38.91 85.7,38.94 85.43,39.21 85.43,40.2 85.74,40.51 85.74,41.07 85.78,41.11 87.47,41.11
VIN_VCCIO on TOP (solid shape): 178.54,52.54 178.54,50.63 178.03,50.12 178.03,49.44 177.93,49.35 177.31,49.35 177.16,49.49 175.65,49.49 175.58,49.56 175.58,50.67 175.65,50.75 176.24,50.75 176.89,51.39 176.89,52.46 177.06,52.64 178.44,52.64
VIN_VCCIO on BOTTOM (solid shape): 178.28,52.16 178.28,50.89 178.18,50.78 178.18,50.78 178.03,50.63 178.03,49.61 177.27,49.61 177.22,49.56 176.72,49.56 176.17,50.1 176.17,52.1 176.26,52.19 176.56,52.1 176.82,52.28 178.16,52.28
+AC_IN on BOTTOM (solid shape): 48.47,78.08 50.68,78.08 50.9,77.86 50.9,75.02 50.78,74.89 48.87,74.89 48.74,75.02 48.74,75.4 48.49,75.65 47.09,75.65 47.09,75.9 47.35,76.16 47.73,76.16 47.97,76.4 47.97,78.12 48.02,78.18 48.38,78.18
+AC_IN on BOTTOM (solid shape): outline of 201 points within 53.7,61.05 59.67,66.76
+AC_IN on IN4 (solid shape): outline of 619 points within 48.24,65.11 60.76,79.59
+DC_IN on TOP (solid shape): 31.6,77.56 31.6,76.79 30.84,76.03 26.9,76.03 26.77,76.16 26.77,77.56 27.15,77.94 31.22,77.94
+DC_IN on BOTTOM (solid shape): 31.22,78.83 31.22,78.32 31.34,78.19 33.38,78.19 33.5,78.06 33.5,77.43 33.38,77.3 32.31,77.3 32.11,77.1 32.11,75.81 31.95,75.65 31.62,75.65 30.86,76.41 29.19,76.41 29.06,76.54 29.06,77.17 29.19,77.3 29.19,77.5 29.19,77.5 29.19,78.19 29.95,78.95 31.09,78.95
+DC_IN_SS on BOTTOM (solid shape): 33.63,76.92 33.63,76.41 33.88,76.16 36.3,76.16 36.34,76.12 36.34,75.71 36.27,75.49 36.34,75.28 36.34,75.13 36.28,75.07 34.44,75.07 34.11,74.75 32.49,74.75 32.23,75 32.23,75.75 32.23,75.75 32.23,77.05 32.36,77.17 33.38,77.17
+DCIN_JACK on TOP (solid shape): 28.62,78.64 28.62,78.27 28.41,78.06 27.1,78.06 26.52,78.06 26.26,77.81 23.72,77.81 23.6,77.94 23.6,78.7 23.72,78.83 28.44,78.83
+DCIN_JACK on BOTTOM (solid shape): 29.06,78.72 29.06,77.56 28.68,77.17 28.68,74.76 28.42,74.51 26.65,74.51 26.63,74.52 25.54,74.52 25.35,74.71 25.35,78.53 25.77,78.95 28.83,78.95
+INV_PWR_SRC on TOP (solid shape): outline of 571 points within 193.27,17.74 201.65,26.63
+INV_PWR_SRC on BOTTOM (solid shape): 194.03,26.37 194.03,24.98 193.78,24.72 192.25,24.72 192.13,24.85 192.13,26.5 193.9,26.5
+LCDVDD on TOP (solid shape): outline of 425 points within 192.79,31.16 202.53,39.12
+LCDVDD on BOTTOM (solid shape): 194.16,35.26 194.16,34.38 193.52,33.74 191.66,33.74 191.44,33.82 191.22,33.74 190.97,33.74 189.61,32.38 189.61,29.82 188.96,29.17 188.96,27.61 188.8,27.44 188.2,27.44 188.05,27.59 188.05,32.04 188.69,32.68 188.69,34.96 189.25,35.52 193.9,35.52
+PBATT on BOTTOM (solid shape): 78.51,28.73 78.51,28.71 78.53,28.58 78.58,28.47 78.61,28.39 78.57,28.33 78.44,27.99 78.68,27.71 78.72,27.7 78.72,26.75 78.67,26.74 78.39,26.39 78.67,26.04 78.72,26.04 78.72,25.74 78.46,25.49 77.83,25.49 77.32,24.98 77.32,23.96 77.06,23.71 75.67,23.71 75.54,23.83 75.54,26.76 75.29,27.01 74.02,27.01 73.76,27.26 73.76,28.79 74.02,29.04 78.21,29.04
+PP_HV on TOP (solid shape): 27.89,62.16 28.58,62.16 28.68,62.06 28.68,60.91 28.5,60.73 27.47,60.73 27.19,61.01 27.19,61.29 26.87,61.61 26.32,61.61 26.1,61.4 25.45,61.4 25.37,61.45 25.36,61.54 25.38,61.58 25.39,61.62 25.49,61.72 25.51,61.72 25.68,61.78 25.76,61.94 25.97,62.15 26.85,62.15 26.89,62.19 27.89,62.19
+PP_HV on IN1 (solid shape): outline of 435 points within 26.34,60.57 33.43,75.22
+PWR_SRC_AC on BOTTOM (solid shape): 50.14,31.96 50.14,30.69 50.27,30.57 50.27,28.41 50.14,28.28 49.89,28.28 49.88,28.27 49.63,28.27 49.63,29.66 49.27,30.02 48.91,29.66 48.91,28.27 48.24,28.27 48.24,28.28 48.24,31.72 48.31,31.79 48.31,31.91 48.74,32.34 49.76,32.34
+RTCVCC on TOP (solid shape): 192.76,58.22 192.92,58.05 193.15,58.02 193.23,58 193.27,57.92 193.27,57.36 193.14,57.24 192,57.24 191.87,57.36 191.87,58.12 192,58.25 192.75,58.25
+RTCVCC on IN2 (solid shape): outline of 382 points within 140.18,48.98 144.5,56.85
+SDC_IN on TOP (solid shape): outline of 183 points within 41.76,21.76 49.99,26.05
+SDC_IN on BOTTOM (solid shape): 48.91,25.9 49.27,25.55 49.63,25.9 49.63,27.29 50.15,27.29 50.27,27.17 50.27,24.31 49.87,23.91 49.87,23.9 49.55,23.58 48.17,23.58 47.91,23.84 47.91,25.32 48.11,25.52 48.11,27.19 48.2,27.29 48.91,27.29
+SDC_IN on BOTTOM (solid shape): 36.05,79.21 39.87,79.21 39.95,79.17 39.97,79.08 39.98,78.87 40.11,78.7 40.11,78.19 38.57,78.19 38.36,77.98 38.36,77.64 38.57,77.43 39.6,77.43 39.6,77.43 40.07,77.43 40.1,77.4 40.1,76.94 40.03,76.87 39.97,76.84 39.92,76.79 37.95,76.79 37.57,76.41 34.9,76.41 34.9,76.92 35.41,77.43 35.41,79.15 35.46,79.21 36.05,79.21
+SDC_IN on IN2 (solid shape): outline of 5308 points within 11.89,14.44 37.82,79.46
+SDC_IN on IN3 (solid shape): outline of 1231 points within 19.41,15.33 50.65,25.36
+VCHGR on TOP (solid shape): 76.64,33.9 76.64,30.9 76.18,30.44 68.17,30.44 67.67,30.95 67.67,31.84 67.79,31.96 70.33,31.96 70.96,32.59 70.96,33.88 71.32,34.25 76.3,34.25
+VCHGR on BOTTOM (solid shape): 77.32,33.99 77.32,32.36 77.24,32.14 77.32,31.91 77.32,30.69 77.06,30.44 73.43,30.44 68.17,30.44 67.67,30.95 67.67,31.84 67.79,31.96 70.33,31.96 71,32.63 71,32.91 72.36,32.91 72.72,33.27 72.36,33.62 71,33.62 71,34.25 77.06,34.25
+VREFCA on BOTTOM (solid shape): outline of 456 points within 136.75,19.77 140.44,26.63
+VREFCA on BOTTOM (solid shape): outline of 1091 points within 102.85,20.32 120.24,26.88
+VREFCA on IN2 (solid shape): outline of 397 points within 99.42,20.89 104.45,26.76
-DCIN_JACK on TOP (solid shape): 26.26,74 26.26,72.37 25.63,71.74 25.63,71.08 25.38,70.82 24.26,70.82 24.17,70.87 24.17,70.97 24.14,71.34 23.8,71.48 23.72,71.5 23.68,71.58 23.66,71.67 23.62,71.76 23.62,74.13 23.75,74.25 26.01,74.25
-DCIN_JACK on BOTTOM (solid shape): 28.68,72.86 28.68,70.95 28.42,70.7 24.35,70.7 24.16,70.89 24.16,70.94 24.16,70.96 24.21,71.14 24.16,71.31 24.16,72.97 24.27,73.08 28.45,73.08
B+ on TOP (solid shape): 178.16,80.1 178.16,78.83 178.03,78.7 177.27,78.7 177.14,78.83 177.14,80.1 177.39,80.35 177.9,80.35
B+ on TOP (solid shape): 73.51,43.65 73.51,34.63 73.38,34.5 70.08,34.5 69.83,34.76 69.83,41.75 69.57,42.01 69.57,43.08 69.63,43.14 71.09,43.14 71.86,43.9 73.25,43.9
B+ on TOP (solid shape): 174.85,39.07 174.85,37.24 174.64,37.02 174.64,36.89 174.5,36.75 174.48,36.75 174.24,36.65 174.13,36.41 174.13,36.39 173.38,35.64 172.07,35.64 171.81,35.9 171.81,37.04 171.93,37.17 172.57,37.17 172.95,37.55 172.95,38.19 172.82,38.31 172.82,39.2 172.95,39.33 174.6,39.33
B+ on TOP (solid shape): 180.06,52.84 180.18,52.82 180.3,52.84 180.31,52.84 180.57,52.84 180.82,52.59 180.82,50.43 180.57,50.17 180.26,50.17 180.24,50.21 180.04,50.4 179.76,50.39 179.73,50.38 179.68,50.43 179.68,51.44 179.55,51.57 179.17,51.57 179.05,51.7 179.05,52.71 179.17,52.84 180.05,52.84
B+ on TOP (solid shape): outline of 159 points within 194.92,13.8 201.57,18.37
B+ on BOTTOM (solid shape): 93.57,28.21 93.57,25.36 93.45,25.23 92.56,25.23 92.43,25.36 92.43,27.64 92.43,27.65 92.43,28.15 92.61,28.33 93.46,28.33
B+ on BOTTOM (solid shape): 86.63,38.1 86.63,37.08 86.59,37.04 86.34,37.04 84.43,35.14 82.78,35.14 81.26,33.61 81.26,31.33 81.13,31.2 80.62,31.2 80.62,31.2 79.99,31.2 79.86,31.33 79.86,32.4 79.99,32.67 79.86,32.95 79.86,34.76 80.75,35.65 81.76,35.65 82.27,36.15 83.97,36.15 84.05,36.15 84.94,37.04 84.94,37.42 85.7,38.19 86.54,38.19
B+ on BOTTOM (solid shape): 73.33,43.61 73.33,42.84 72.77,42.84 72.77,42.08 73.33,42.08 73.33,41.64 72.77,41.64 72.77,40.88 73.33,40.88 73.33,40.14 73.64,39.84 73.64,34.63 73.51,34.5 70.71,34.5 69.99,33.78 69.99,33.62 68.6,33.62 68.24,33.27 68.6,32.91 69.99,32.91 69.99,32.38 69.83,32.22 67.54,32.22 67.16,31.84 67.16,30.69 66.65,30.18 63.48,30.18 63.22,30.44 63.22,35.19 64.69,36.66 68.89,36.66 69.83,37.6 69.83,38.39 69.57,38.64 69.57,42.63 69.58,42.64 69.58,43.07 69.63,43.13 71.08,43.13 71.86,43.9 73.04,43.9
B+ on BOTTOM (solid shape): outline of 382 points within 54.97,51.01 64.05,62.33
B+ on IN2 (solid shape): outline of 569 points within 172.7,35.52 181.33,52.16
B+ on IN2 (solid shape): outline of 1011 points within 175.74,14.94 195.68,22.18
B+ on IN2 (solid shape): outline of 2774 points within 53.95,30.82 81.13,55.97
B+ on IN3 (solid shape): outline of 838 points within 179.55,47.51 199.24,75.02
B+ on IN3 (solid shape): outline of 1093 points within 159.61,15.83 176.63,37.7
B+ on IN3 (solid shape): outline of 3579 points within 69.44,16.85 95.99,41.87
B+ on IN4 (solid shape): outline of 417 points within 92.61,15.8 163.42,18.42
B+ on GND3: 166.07,14.44 165.56,14.94 100.92,14.94 99.65,16.21 93.68,16.21 93.19,16.7 93.19,18.01 94.44,19.26 99.82,19.26 101.09,17.99 115.9,17.99 116.41,18.5 117.09,18.5 117.6,17.99 163.19,17.99 163.45,17.74 164.16,17.74 164.42,17.99 174.75,17.99 175.11,17.63 175.11,15.56 174.49,14.94 166.75,14.94 166.24,14.44
B+_1.0V on TOP (solid shape): 197.59,64.22 197.59,63.33 197.46,63.2 196.19,63.2 195.68,62.7 194.29,62.7 194.03,62.95 194.03,64.22 194.1,64.29 197.52,64.29
B+_1.0V on BOTTOM (solid shape): 198.32,64.86 200.1,64.86 200.1,63.99 198.12,63.99 197.33,63.2 196.57,63.2 196.06,62.7 195.88,62.7 194.21,62.7 194.03,62.87 194.03,64.6 194.15,64.72 194.18,64.71 194.43,64.69 194.63,64.86 194.96,64.86 194.97,64.85 195.1,64.83 195.22,64.85 195.23,64.86 195.58,64.86 195.58,65.24 196.09,65.74 197.43,65.74
B+_3V on TOP (solid shape): 94.21,24.09 94.21,22.44 93.93,22.16 92.35,22.16 91.89,22.62 91.38,22.62 90.94,22.18 89.48,22.18 89.48,22.72 89.13,23.07 89.13,23.58 89.76,24.22 94.08,24.22
B+_3V on BOTTOM (solid shape): 94.18,24.11 94.18,22.41 93.93,22.16 92.35,22.16 91.82,22.69 91.24,22.69 90.8,22.25 90.8,21.93 90.74,21.87 89.27,21.87 89.2,21.93 89.2,23.21 90.42,24.44 93.86,24.44
B+_3V on IN2 (solid shape): 92.42,24.08 92.42,22.8 92.43,22.79 92.43,22.69 92.3,22.56 89.13,22.56 88.88,22.82 88.88,23 88.88,23.01 88.92,23.15 88.89,23.3 88.88,23.33 88.94,23.4 89.6,23.4 90.42,24.21 92.29,24.21
B+_5V on TOP (solid shape): 67.57,45.17 67.79,45.09 68.01,45.17 70.97,45.17 71.22,44.92 71.22,44.23 71.22,44.01 71.1,43.89 70.98,43.89 70.98,43.9 69.58,43.9 69.58,43.89 69.52,43.89 69.41,43.77 69.41,43.49 69.3,43.39 69.24,43.39 65.13,43.39 64.62,43.9 63.09,43.9 62.97,44.03 62.97,44.92 63.22,45.17
B+_5V on BOTTOM (solid shape): 67.41,45.17 67.42,45.17 67.56,45.03 68.03,45.03 68.17,45.17 70.97,45.17 71.22,44.92 71.22,44.03 71.15,43.95 69.58,43.95 69.42,43.79 69.42,43.53 69.28,43.39 65.89,43.39 65.51,43.77 64.75,43.77 64.55,43.58 62.98,43.58 62.91,43.65 62.91,44.42 62.84,44.49 62.84,45.25 63.02,45.42 67.16,45.42
BATBTN# on TOP (solid shape): 4.67,24.34 4.67,24.15 4.64,24.07 4.55,24.05 4.15,23.87 4.24,23.44 4.28,23.36 4.24,23.28 4.16,22.85 4.55,22.67 4.64,22.65 4.67,22.57 4.67,21.68 4.29,21.29 4.29,21.09 4.17,20.97 4.17,20.61 4.37,20.4 5.44,20.4 5.56,20.28 5.56,18.5 5.44,18.37 3.02,18.37 2.77,18.63 2.77,21.04 2.9,21.17 2.9,24.34 3.02,24.47 4.55,24.47
BQ24777_REGN on BOTTOM (solid shape): 47.09,32.6 47.09,32.34 46.71,31.96 46.71,30.82 46.46,30.57 45.57,30.57 45.31,30.31 45.31,30.06 44.95,29.69 44.92,29.7 44.83,29.71 44.73,29.68 44.72,29.68 44.37,29.68 44.31,29.61 43.36,29.61 43.31,29.66 43.31,29.77 43.35,29.81 44.19,29.81 44.2,29.8 44.66,29.8 44.67,29.81 44.69,29.81 44.93,30.06 44.93,30.08 44.93,31 44.93,31 44.93,31.2 45.82,32.09 45.82,32.6 45.95,32.72 46.97,32.72
BST_3V on BOTTOM (solid shape): 89.03,23.23 89.03,21.95 88.95,21.88 88.8,21.88 88.62,22.06 87.86,22.06 87.73,22.18 87.73,23.08 88.06,23.4 88.85,23.4
BST_5V on BOTTOM (solid shape): 62.71,45.24 62.71,44.44 62.71,43.66 62.64,43.58 62.47,43.58 62.42,43.63 62.09,43.63 61.95,43.77 61.95,45.26 62.06,45.37 62.58,45.37
CHAGER_SRC on TOP (solid shape): 51.28,36.53 51.28,35.77 51.54,35.52 51.54,30.18 52.05,29.68 55.22,29.68 55.35,29.55 55.35,25.74 54.59,24.98 51.49,24.98 50.52,25.95 50.52,30.69 50.39,30.82 50.39,32.85 50.14,33.11 48.36,33.11 48.11,33.36 48.11,35.49 48.24,35.62 49,35.62 49.96,36.58 51.23,36.58
CHAGER_SRC on BOTTOM (solid shape): 50.9,36.53 50.9,35.9 51.03,35.77 51.28,35.77 51.54,35.52 51.54,30.18 52.05,29.68 55.22,29.68 55.35,29.55 55.35,25.74 54.95,25.35 51.31,25.35 51.3,25.34 50.68,25.34 50.52,25.5 50.52,30.69 50.39,30.82 50.39,32.85 50.14,33.11 48.36,33.11 48.11,33.36 48.11,36.41 48.36,36.66 50.78,36.66
CHG_BTS on BOTTOM (solid shape): 46.33,30.18 46.33,29.42 46.2,29.3 44.43,29.3 44.33,29.2 44.05,29.2 44.05,29.2 43.37,29.2 43.3,29.27 43.3,29.36 43.37,29.42 44.3,29.42 44.43,29.55 45.06,29.55 45.63,30.12 45.63,30.25 46.27,30.25
CHG_LGATE on BOTTOM (solid shape): 54.84,34.38 54.84,33.61 54.59,33.36 53.7,33.36 53.44,33.61 53.44,34.38 53.57,34.5 54.71,34.5
CHG_LGATE on BOTTOM (solid shape): 44.81,30.95 44.81,30.13 44.6,29.93 44.25,29.93 44.19,30 43.62,30 43.61,29.99 43.31,29.99 43.28,30.02 43.28,30.18 43.32,30.22 44.21,30.22 44.3,30.31 44.3,30.41 44.3,30.42 44.32,30.51 44.3,30.61 44.3,30.62 44.3,30.92 44.31,30.96 44.43,31.07 44.68,31.07
CHG_LGATE on IN1 (solid shape): 54.84,34.25 54.84,32.98 54.71,32.85 53.95,32.85 53.57,33.23 53.57,34.38 53.7,34.5 54.59,34.5
CHG_LGATE on IN1 (solid shape): 45.95,31.33 45.95,31.07 45.57,30.69 44.93,30.69 44.81,30.57 44.81,30.06 44.68,29.93 44.43,29.93 44.3,30.06 44.3,30.91 44.3,30.92 44.32,31.04 44.3,31.17 44.29,31.2 44.51,31.41 44.54,31.39 44.82,31.37 45.02,31.55 45.04,31.58 45.7,31.58
CHG_SW on BOTTOM (solid shape): 61.44,34.88 61.44,30.69 60.43,29.68 58.78,29.68 57.89,28.79 57.89,26.88 57.63,26.63 56.11,26.63 55.86,26.88 55.86,30.57 55.09,31.33 55.09,33.87 55.98,34.76 55.98,36.28 56.24,36.53 59.79,36.53
CHG_SW on BOTTOM (solid shape): 46.84,28.91 46.84,28.08 46.76,28 46.4,28 46.3,27.9 46.13,27.9 45.09,27.9 45,27.91 44.9,27.9 44.68,27.9 44.17,28.41 43.36,28.41 43.31,28.46 43.31,28.56 43.36,28.61 44.34,28.61 44.43,28.53 45.44,28.53 45.57,28.66 45.57,28.91 45.7,29.04 46.71,29.04
CHG_SW on IN1 (solid shape): 58.65,36.27 58.65,34.76 58.52,34.63 57.89,34.63 57.63,34.88 57.63,36.25 57.78,36.4 58.53,36.4
CHG_SW on IN1 (solid shape): 47.73,28.79 47.73,28.15 47.47,27.9 46.8,27.9 46.58,27.97 46.36,27.9 46.33,27.9 46.08,28.15 46.08,28.91 46.2,29.04 47.47,29.04
CHG_UGATE on BOTTOM (solid shape): 57.38,25.87 57.38,24.85 57.25,24.72 56.13,24.72 55.98,24.87 55.98,25.87 56.24,26.12 57.13,26.12
CHG_UGATE on BOTTOM (solid shape): 44.76,29.17 44.85,29.15 44.95,29.17 44.95,29.17 45.31,29.17 45.44,29.04 45.44,28.79 45.31,28.66 44.48,28.66 44.35,28.79 43.35,28.79 43.31,28.83 43.31,28.99 43.33,29.02 44.3,29.02 44.36,29.07 44.38,29.07 44.48,29.17 44.76,29.17
CHG_UGATE on IN4 (solid shape): 57.38,25.49 57.38,24.85 57.25,24.72 54.83,24.72 54.5,25.05 54.5,25.76 54.82,26.08 56.79,26.08
CHG_UGATE on IN4 (solid shape): 46.46,30.18 46.46,29.42 46.2,29.17 45.7,29.17 45.44,28.91 45.44,28.79 45.31,28.66 44.43,28.66 44.3,28.79 44.3,29.3 45.31,30.31 46.33,30.31
CORE_SW on TOP (solid shape): 90.27,65.36 90.27,63.59 90.15,63.46 89.76,63.46 89.64,63.33 89.64,62.57 89.76,62.44 90.15,62.44 90.27,62.32 90.27,60.79 89.43,59.95 88.16,59.95 87.99,60.13 87.99,61.65 87.83,61.81 84.25,61.81 83.82,62.24 83.82,64 84.14,64.32 85.26,64.32 86.83,65.89 89.74,65.89
CORE_SW on BOTTOM (solid shape): 89.49,66.27 89.49,66.26 89.59,66.08 89.77,65.98 89.79,65.98 90.4,65.36 90.4,63.84 90.02,63.46 88.78,63.46 88.65,63.33 88.65,62.67 88.88,62.44 90.15,62.44 90.4,62.19 90.4,60.66 89.64,59.9 86.59,59.9 84.94,61.55 84.51,61.55 83.82,62.23 83.82,64.49 84.7,64.49 84.77,64.51 84.83,64.48 85.34,64.48 85.34,64.99 85.31,65.06 85.34,65.13 86.97,66.76 89,66.76
CORE_SW on IN1 (solid shape): 89.51,65.36 89.51,60.28 89.13,59.9 86.84,59.9 85.07,61.68 85.07,63.97 86.72,65.62 89.26,65.62
CPU_B+ on TOP (solid shape): 80.87,64.09 80.87,61.68 81.26,61.3 81.26,58.25 81.13,58.12 80.4,58.12 80.24,58.28 80.24,58.76 79.73,59.27 78.72,59.27 78.59,59.39 78.59,61.05 78.84,61.3 79.1,61.3 79.22,61.43 79.22,63.33 80.06,64.17 80.24,64.17 80.3,64.22 80.75,64.22
CPU_B+ on TOP (solid shape): 80.75,56.47 80.75,53.17 81,52.92 81,51.52 80.87,51.39 79.99,51.39 79.86,51.52 79.86,52.54 79.68,52.71 79.68,52.73 79.42,53.08 79.02,52.92 78.88,52.92 78.63,53.07 78.35,52.97 78.31,52.94 78.24,53.01 78.26,53.04 78.24,53.33 78,53.5 77.95,53.5 77.95,54.31 78.59,54.95 78.59,55.46 78.84,55.71 79.86,55.71 80.11,55.97 80.11,56.47 80.24,56.6 80.62,56.6
CPU_B+ on TOP (solid shape): outline of 118 points within 75.67,39.71 80.62,48.73
CPU_B+ on BOTTOM (solid shape): outline of 376 points within 73.47,36.15 81.23,64.49
GT_SW1 on TOP (solid shape): 89.26,49.74 89.26,44.6 88.81,44.15 86.29,44.15 86.17,44.23 86.03,44.24 86.01,44.24 85.26,45 85.26,45.49 87.92,45.49 87.92,46.76 85.18,46.76 84.94,47 84.94,48.47 86.59,50.12 88.88,50.12
GT_SW1 on BOTTOM (solid shape): 89.26,49.74 89.26,48.22 89,47.96 89,47.96 88.64,47.6 88.64,46.93 89,46.57 89,46.57 89.26,46.31 89.26,44.28 88.62,43.65 86.21,43.65 83.78,46.07 83.78,48.4 84.84,48.4 86.61,50.17 88.82,50.17
GT_SW1 on IN1 (solid shape): 89.51,49.36 89.51,45.04 88.75,44.28 85.83,44.28 85.19,44.92 85.19,48.47 86.72,50 88.88,50
GT_SW2 on TOP (solid shape): 89.38,57.62 89.38,52.41 89.26,52.28 85.45,52.28 85.45,53.11 85.7,53.11 85.7,53.36 85.89,53.36 85.89,53.11 87.8,53.11 87.8,54.38 85.89,54.38 85.89,54.12 85.7,54.12 85.7,54.25 84.81,54.25 84.81,53.11 85.06,53.11 85.06,52.28 84.81,52.28 84.43,52.66 84.43,54.31 83.92,54.82 83.92,55.84 84.68,56.6 85.45,56.6 85.66,56.81 85.67,56.82 85.75,56.88 85.81,56.96 85.81,56.97 86.72,57.87 89.13,57.87
GT_SW2 on BOTTOM (solid shape): 89.38,57.62 89.38,55.84 89.26,55.71 89.25,55.71 88.9,55.36 88.76,55.36 88.66,55.26 88.66,54.62 88.76,54.51 89.14,54.51 89.38,54.27 89.38,52.41 89.26,52.28 85.19,52.28 83.78,53.69 83.78,56.03 84.87,56.03 85.66,56.81 85.67,56.82 85.75,56.88 85.81,56.96 85.81,56.97 86.72,57.87 89.13,57.87
GT_SW2 on IN1 (solid shape): 89.38,57.36 89.38,52.79 88.88,52.28 85.57,52.28 85.32,52.54 85.32,56.35 86.59,57.62 89.13,57.62
LX_1.0V on BOTTOM (solid shape): 200.07,61.74 200.51,61.3 202.14,61.3 202.21,61.24 202.48,61.24 202.51,61.2 202.51,60.61 202.34,60.44 201.83,60.44 201.42,60.03 201.42,59.8 199.75,58.12 197.19,58.12 197.08,58.24 197.08,60.75 197.5,61.17 198.48,61.17 198.92,61.62 198.92,62.84 200.07,62.84
LX_1V_PRIM on BOTTOM (solid shape): 88.91,29.77 91.06,29.77 91.67,29.16 91.67,28.03 91.54,27.9 91.33,27.9 91.06,27.62 91.06,26.93 91.01,26.88 90.03,26.88 89.93,26.98 89.93,27.14 89.18,27.9 88.62,27.9 88.49,28.03 88.49,29.17 88.18,29.49 87.32,29.49 87.26,29.55 87.26,30.17 87.33,30.24 88.44,30.24
LX_3V on TOP (solid shape): 85.67,22.54 85.67,22.08 85.95,21.8 86.72,21.8 86.84,21.68 86.84,19.64 86.59,19.39 83.29,19.39 82.91,19.77 82.91,22.69 82.93,22.72 84.02,22.72 84.05,22.74 85.47,22.74
LX_3V on BOTTOM (solid shape): 87.62,21.79 88.6,21.79 88.67,21.71 90.79,21.71 90.86,21.79 91.7,21.79 91.77,21.71 91.77,21.61 91.7,21.53 90.95,21.53 90.88,21.46 89.19,21.46 88.81,21.08 87.65,21.08 86.72,20.15 86.72,19.01 86.34,18.63 84.81,18.63 84.3,19.14 84.3,22.56 84.56,22.82 86.59,22.82
LX_5V on TOP (solid shape): 59.03,44.54 59.03,43.52 59.28,43.27 60.17,43.27 60.23,43.21 60.23,41.93 60.17,41.87 57.51,41.87 57.25,42.12 57.25,44.15 57.89,44.79 58.78,44.79
LX_5V on BOTTOM (solid shape): 61.2,43.5 62.37,43.5 62.42,43.45 64.6,43.45 64.66,43.5 65.41,43.5 65.48,43.43 65.48,43.32 65.41,43.25 64.61,43.25 64.53,43.18 62.5,43.18 62.46,43.14 62.46,42.88 62.38,42.8 60.98,42.8 60.81,42.63 60.81,40.39 60.58,40.17 57.68,40.17 57.25,40.6 57.25,43.87 58.17,44.79 59.92,44.79
LX_DDR on TOP (solid shape): 169.9,30.82 169.9,29.02 171.4,27.52 173.2,27.52 173.58,27.14 173.58,25.49 173.33,25.23 172.36,25.23 171.86,24.72 167.31,24.72 166.98,25.05 166.98,26.76 168.5,28.28 168.5,30.84 168.61,30.95 169.77,30.95
LX_PRIM on TOP (solid shape): 198.92,74.95 198.92,74.34 198.84,74.27 197.98,74.27 197.71,74 197.71,72.86 197.46,72.6 195.97,72.6 195.88,72.61 195.78,72.6 195.68,72.6 195.56,72.48 195.56,72.41 195.55,72.4 195.52,72.26 195.55,72.11 195.56,72.1 195.56,71.59 195.43,71.46 194.79,71.46 194.67,71.59 194.67,73.62 194.73,73.68 194.76,73.67 195.02,73.67 195.22,73.85 195.29,73.9 195.38,73.88 195.65,73.77 195.91,73.91 195.99,73.95 196.07,73.91 196.39,73.77 196.68,73.97 196.68,73.98 197.72,75.02 198.85,75.02
LX_VCC_EDRAM on BOTTOM (solid shape): 94.56,39.3 94.56,38.03 94.46,37.93 93.07,37.93 92.69,37.55 92.69,36.66 92.56,36.53 91.8,36.53 91.67,36.66 91.67,38.27 91.41,38.53 90.48,38.53 90.42,38.6 90.42,39.23 90.48,39.29 91.44,39.29 91.71,39.56 94.3,39.56
LX_VCCIO on TOP (solid shape): 173.37,50.17 173.37,49.55 173.3,49.49 172.31,49.49 172.06,49.23 172.06,47.96 171.81,47.71 171.04,47.71 170.79,47.46 170.79,46.82 170.66,46.69 170.03,46.69 169.9,46.82 169.9,47.46 169.52,47.84 168.85,47.84 168.5,48.19 168.5,49.23 168.89,49.62 171.68,49.62 172.31,50.25 173.3,50.25
PBATT+_C on BOTTOM (solid shape): 71.72,28.55 72.14,28.55 72.18,28.54 72.24,28.53 74.02,26.76 74.78,26.76 75.03,26.5 75.03,23.96 75.54,23.45 75.92,23.45 76.05,23.33 76.05,22.56 75.92,22.44 75.41,22.44 75.29,22.56 75.29,23.2 75.03,23.45 71.9,23.45 71.65,23.56 71.4,23.45 69.44,23.45 69.19,23.71 69.19,28.53 69.32,28.66 71.6,28.66
RING2 on TOP (solid shape): 28.59,34.29 28.59,33.35 28.38,33.14 28.38,32.34 28.32,32.27 28.2,32.27 28.2,32.28 28.1,32.38 28.1,33.42 28.1,33.43 28.12,33.55 28.1,33.66 28.1,33.67 28.1,34.25 28.21,34.36 28.52,34.36
RING2 on TOP (solid shape): 8.87,24.72 8.87,24.22 8.74,24.09 8.1,24.09 7.85,23.83 7.85,23.07 7.85,23.07 7.85,22.99 8.19,22.66 8.25,22.66 8.28,22.63 8.28,22.15 8.22,22.09 7.69,22.09 7.6,22.18 7.6,22.44 7.49,22.54 7.49,22.77 7.26,22.77 7.09,22.95 7.09,24.47 7.47,24.85 8.74,24.85
RING2 on IN2 (solid shape): outline of 754 points within 7.72,22.87 28.71,36.28
RING2_R on TOP (solid shape): 16.99,27.26 16.61,26.88 16.23,26.88 15.98,26.63 15.98,23.83 13.31,21.17 6.66,21.17 6.58,21.2 6.55,21.27 6.2,21.65 5.84,21.27 5.81,21.2 5.74,21.17 5.18,21.17 5.06,21.29 5.06,22.69 5.56,23.2 5.94,22.82 6.2,22.82 6.58,22.44 6.58,22.06 6.71,21.93 7.52,21.93 7.66,21.79 8.47,21.79 8.83,22.15 8.94,22.17 9,22.08 9.22,21.77 9.59,21.83 9.66,21.85 9.72,21.83 10.3,22.11 9.71,22.38 9.65,22.35 9.58,22.37 9.48,22.43 9.37,22.45 9.28,22.52 9.31,22.62 10.14,23.45 13.69,23.45 14.96,24.72 14.96,28.03 15.06,28.12 16.99,28.12
SA_B+ on TOP (solid shape): 65.96,62.82 67.34,62.82 67.41,62.75 67.69,62.75 67.77,62.82 69.24,62.82 69.24,62.82 69.62,62.82 69.66,62.78 70.25,62.78 70.4,62.63 70.4,62.38 69.76,61.74 69.76,61.43 69.38,61.05 66.14,61.05 65.63,61.55 65.63,62.57 65.89,62.82
SA_B+ on BOTTOM (solid shape): 70.71,62.95 70.71,62.57 70.59,62.44 70.08,62.44 69.95,62.32 69.95,61.29 69.76,61.1 67.36,61.1 67.03,61.43 66.01,61.43 65.85,61.26 64.25,61.26 64.11,61.4 64.11,62.44 64.52,62.85 67.34,62.85 67.39,62.8 67.86,62.8 68.07,63.01 70.66,63.01
SLEEVE on TOP (solid shape): 27.97,34.27 27.97,32.28 27.73,32.28 27.68,32.33 27.69,32.38 27.69,33.35 27.44,33.6 27.44,34.27 27.54,34.37 27.63,34.37 27.63,34.37 27.87,34.37
SLEEVE on BOTTOM (solid shape): 10.26,22.46 10.26,21.84 10.1,21.68 7.6,21.68 7.47,21.8 7.47,22.45 7.57,22.55 10.17,22.55
SLEEVE on IN3 (solid shape): outline of 735 points within 8.74,21.04 28.04,34.5
SLEEVE_R on TOP (solid shape): 18.77,27.01 18.77,26.78 18.67,26.53 18.77,26.28 18.77,25.6 18.72,25.51 18.69,25.42 18.69,25.4 18.64,25.36 17.88,25.36 17.76,25.49 17.76,26.38 17.74,26.46 17.8,26.53 17.99,26.73 17.98,27 17.98,27.1 18.06,27.15 18.18,27.18 18.28,27.26 18.52,27.26
SLEEVE_R on BOTTOM (solid shape): outline of 88 points within 5.44,22.82 8.23,25.99
SNUB_1.8VA on TOP (solid shape): 170.5,77.96 170.5,77.73 170.59,77.64 170.59,77.52 172.19,75.92 172.19,74.63 172.08,74.53 172.06,74.53 171.3,74.53 171.25,74.53 171.19,74.51 171.04,74.51 171,74.47 170.99,74.47 170.9,74.38 169.4,74.38 169.27,74.51 169.27,77.81 169.52,78.06 170.4,78.06
SNUB_1.8VU on TOP (solid shape): 167.01,44.88 167.01,44.28 166.98,44.21 166.91,44.18 166.55,43.78 166.99,43.48 167.01,43.48 167.49,43.01 167.49,41.8 167.44,41.76 166.11,41.76 165.84,41.49 165.84,41.11 165.71,40.98 164.82,40.98 164.44,41.36 164.44,44.66 164.82,45.04 166.84,45.04
SPK_L+_C on TOP (solid shape): outline of 89 points within 21.49,15.83 24.36,20.41
SPK_L+_C on BOTTOM (solid shape): 26.65,17.36 26.65,16.6 26.52,16.47 24.49,16.47 23.98,15.96 22.45,15.96 22.2,16.21 22.2,16.85 22.58,17.23 22.96,17.23 23.22,17.48 26.52,17.48
SPK_L-_C on TOP (solid shape): 26.14,20.28 26.14,17.74 25.63,17.23 25.63,15.45 24.49,14.31 22.2,14.31 22.07,14.44 22.07,15.45 22.2,15.58 23.98,15.58 24.49,16.09 24.49,17.48 25.25,18.25 25.25,19.67 25.1,19.67 24.99,19.77 24.99,20.28 25.12,20.41 26.01,20.41
SPK_L-_C on BOTTOM (solid shape): 26.77,15.96 26.77,15.58 26.65,15.45 25.25,15.45 24.61,14.82 24.61,13.93 24.36,13.67 23.47,13.67 23.22,13.93 23.22,14.69 24.74,16.21 26.52,16.21
SPK_OUT_L+ on TOP (solid shape): 27.57,27.02 27.57,25.36 27.53,25.32 27.53,24.99 27.05,24.5 26.83,24.5 26.7,24.62 26.7,24.82 27.33,25.45 27.33,27.02 27.39,27.07 27.52,27.07
SPK_OUT_L+ on TOP (solid shape): 23.35,21.8 23.54,21.74 23.72,21.8 24.61,21.8 24.74,21.68 24.74,20.66 24.61,20.53 24.29,20.53 24.23,20.53 24.23,20.54 23.33,20.54 23.32,20.55 23.28,20.64 23.22,20.72 23.22,21.68 23.34,21.8
SPK_OUT_L+ on IN1 (solid shape): 28.8,25.13 28.8,23.38 27.44,22.01 27.41,22.02 27.01,21.95 26.93,21.55 26.95,21.52 25.71,20.28 24.11,20.28 23.98,20.41 23.98,21.55 24.11,21.68 25.12,21.68 27.15,23.71 27.15,24.39 26.82,24.72 26.82,25 27.07,25.25 27.15,25.31 27.21,25.39 27.23,25.41 28.52,25.41
SPK_OUT_L- on TOP (solid shape): 27.97,27.03 27.97,25.3 28.04,25.23 28.04,25.1 28.42,24.72 28.42,24.22 27.79,23.58 27.79,22.31 27.47,21.99 27.43,22.01 27.01,21.95 26.95,21.52 26.97,21.49 26.02,20.54 25.11,20.54 24.99,20.66 24.99,21.55 26.39,22.95 26.39,23.58 27.66,24.85 27.66,24.97 27.67,24.98 27.71,25.12 27.7,25.27 27.69,25.28 27.69,25.3 27.74,25.35 27.74,27.03 27.79,27.08 27.93,27.08
SPK_OUT_R+ on TOP (solid shape): 28.83,26.99 28.83,26 28.82,25.99 28.82,25.71 28.83,25.68 28.93,25.46 29.15,25.36 29.17,25.36 29.62,24.91 29.66,24.91 29.67,24.9 30.35,24.9 30.59,24.66 30.59,22.77 30.5,22.67 30.5,21.76 30.59,21.66 30.59,21.15 29.37,21.15 29.31,21.21 29.31,23.07 29.57,23.33 29.57,24.52 28.53,25.55 28.53,27 28.61,27.08 28.74,27.08
SPK_OUT_R- on TOP (solid shape): 28.37,27.01 28.37,25.53 29.44,24.47 29.44,23.45 29.06,23.07 29.06,20.66 28.93,20.53 28.17,20.53 28.05,20.65 28.05,21.42 28.04,21.42 28.04,23.58 28.55,24.09 28.55,24.78 28.17,25.16 28.17,25.28 28.14,25.31 28.14,27.01 28.2,27.07 28.31,27.07
SPK_R+_C on TOP (solid shape): 30.69,20.8 30.69,19.98 30.96,19.7 30.96,16.85 30.62,16.51 30.52,16.49 30.45,16.57 29.85,16.77 30.05,16.17 30.13,16.1 30.11,15.99 30.07,15.96 30.07,14.94 29.98,14.8 29.98,14.62 29.98,14.6 29.82,14.44 28.42,14.44 28.17,14.69 28.17,16.34 30.07,18.25 30.07,18.47 30.27,18.75 30.17,19.07 30.07,19.17 30.07,19.26 29.95,19.39 29.95,20.15 29.73,20.37 29.73,20.39 29.72,20.47 29.7,20.54 29.69,20.55 29.69,20.79 29.82,20.91 30.58,20.91
SPK_R+_C on BOTTOM (solid shape): 29.72,14.92 29.72,13.95 29.08,13.32 25.35,13.32 24.99,13.67 24.99,14.13 25.2,14.33 28.19,14.33 28.85,14.99 29.64,14.99
SPK_R-_C on TOP (solid shape): 27.92,21.42 27.92,19.26 27.28,18.63 27.28,18.27 27.28,18.25 27.28,17.74 27.28,17.72 27.28,16.98 27.66,16.6 27.66,14.69 27.41,14.44 26.39,14.44 26.14,14.69 26.14,17.36 26.26,17.48 26.26,17.69 26.26,17.69 26.26,20.08 26.71,20.08 26.71,20.02 26.72,19.97 26.73,19.92 26.76,19.87 26.79,19.83 26.82,19.79 26.86,19.75 26.91,19.73 26.96,19.71 27.01,19.7 27.06,19.69 27.12,19.7 27.17,19.71 27.22,19.73 27.27,19.75 27.31,19.79 27.34,19.83 27.37,19.87 27.4,19.92 27.41,19.97 27.42,20.02 27.42,20.08 27.41,20.13 27.4,20.18 27.37,20.23 27.34,20.27 27.31,20.31 27.27,20.34 27.22,20.37 27.17,20.39 27.12,20.4 27.06,20.41 27.01,20.4 26.96,20.39 26.91,20.37 26.86,20.34 26.82,20.31 26.79,20.27 26.76,20.23 26.73,20.18 26.72,20.13 26.71,20.08 26.26,20.08 26.26,20.33 26.26,20.33 26.26,20.53 27.11,21.38 27.16,21.36 27.21,21.35 27.27,21.34 27.32,21.35 27.37,21.36 27.42,21.38 27.47,21.41 27.51,21.44 27.54,21.48 27.57,21.52 27.58,21.55 27.79,21.55
SPK_R-_C on BOTTOM (solid shape): 27.86,14.92 27.86,14.66 27.71,14.51 25.17,14.51 24.99,14.69 24.99,14.94 25.2,15.15 27.64,15.15
TBT_SVR_IND on TOP (solid shape): 38.58,55.84 38.66,55.76 38.71,55.71 38.76,55.7 38.82,55.69 38.87,55.63 38.87,55.36 38.57,55.05 38.57,54.17 38.18,53.78 38.15,53.78 38.15,53.78 37.68,53.78 37.68,53.78 37.53,53.79 37.45,53.78 37.33,53.78 37.01,53.47 36.55,53.01 36.55,49.62 36.12,49.19 35.02,49.19 34.77,49.43 34.77,53.8 35.14,54.16 36.4,54.16 36.81,54.57 37.95,54.57 38.2,54.82 38.2,55.93 38.36,56.09 38.58,56.09
TBT_VBUS on TOP (solid shape): 18.25,56.68 18.3,56.67 18.35,56.65 18.38,56.63 18.8,56.63 19.03,56.41 19.03,55.46 19.28,55.2 20.39,55.2 20.8,54.79 20.8,53.43 20.68,53.3 17.88,53.3 17.76,53.43 17.76,54.64 17.76,56.19 17.76,56.23 18,56.47 18.03,56.55 18.11,56.64 18.23,56.68
TBT_VBUS on BOTTOM (solid shape): 17.95,56.73 18.64,56.73 18.96,57.04 20.1,57.04 20.36,56.79 20.36,54.82 20.1,54.57 18.71,54.57 17.88,55.39 17.12,55.39 16.85,55.66 16.85,56.84 17.06,57.04 17.63,57.04
TBT_VBUS on BOTTOM (solid shape): 46.33,75.9 46.32,75.79 46.33,75.71 46.33,75.42 46.36,75.4 48.49,75.4 48.62,75.27 48.62,74.96 48.62,74 48.49,73.87 45.24,73.87 44.39,74.72 44.39,75.33 44.53,75.48 44.55,75.48 44.74,75.57 44.83,75.76 44.83,75.78 45.09,76.03 45.13,76.03 46.2,76.03
TBT_VBUS on VCC: 8.84,54.44 5.35,57.94 5.71,58.04 5.87,58.39 5.87,59.19 5.56,59.62 5.06,59.47 5.06,62.11 5.56,61.96 5.86,62.39 5.86,63.19 5.56,63.62 5.06,63.46 5.06,66.65 7.12,67.56 8.1,68.4 8.47,69.64 8.47,70.12 8.98,71.34 10.2,71.85 14.5,71.85 16.11,72.52 16.77,74.12 16.77,79.23 44,79.23 45.15,79.66 45.75,80.73 47.73,80.73 47.73,70.68 44.7,67.65 24,67.65 21.57,65.21 21.57,55.44 20.57,54.44 ; 2 cut-outs
TBT_VBUS_L on TOP (solid shape): 22.26,59.92 22.26,59.91 22.33,59.79 22.44,59.73 22.45,59.72 22.59,59.59 22.59,59.38 22.28,59.06 22.27,59.06 22.21,59.03 22.18,59 21.82,58.64 21.82,58.63 21.33,58.15 21.18,58.15 21.16,58.13 20.86,58.13 20.79,58.06 20.77,58.06 20.77,58.04 20.73,58 20.73,55.63 20.55,55.46 19.41,55.46 19.28,55.58 19.28,56.47 19.53,56.73 19.53,57.93 20.34,58.74 20.62,58.74 20.63,58.75 20.94,58.8 21.1,59.07 21.1,59.09 21.26,59.25 21.26,59.33 21.29,59.36 21.29,59.45 21.51,59.67 21.69,59.67 21.87,59.85 21.87,60.03 21.95,60.11 22.07,60.11
N15438182 on TOP (solid shape): 44.03,27.78 44.03,27.77 44.33,27.26 44.68,27.74 44.67,27.77 44.8,27.9 45.06,27.9 45.31,27.64 45.31,26.63 44.93,26.25 44.93,25.1 44.81,24.98 43.28,24.98 43.16,25.1 43.16,27.26 43.79,27.9 44.03,27.9
N15438182 on BOTTOM (solid shape): 44.2,28.19 44.2,27.94 44.18,27.31 44.7,27.66 44.73,27.74 44.8,27.77 46.08,27.77 46.2,27.64 46.2,26.12 46.08,25.99 45.01,25.99 45.01,26.15 44.27,26.15 43.28,27.14 43.28,28.15 43.35,28.22 44.17,28.22
N52893865 on TOP (solid shape): 174.1,19.47 174.1,18.52 174.47,18.14 174.47,17.61 174.22,17.36 174.04,17.36 173.97,17.39 173.94,17.46 173.79,17.78 173.43,17.81 173.4,17.79 173.2,17.99 172.06,17.99 172,18.06 172,18.7 172.17,18.88 172.7,18.88 173.36,19.54 174.02,19.54
N52893895 on TOP (solid shape): 170.6,18.86 170.6,18.06 170.54,17.99 169.77,17.99 169.65,18.12 168.38,18.12 168.25,18.25 168.25,18.73 168.53,19.01 170.46,19.01
N52922903 on TOP (solid shape): 178.98,31.77 178.98,30.73 178.51,30.26 178.51,29.79 178.23,29.5 178.23,28.66 177.27,28.66 177.14,28.79 177.14,30.99 177.68,31.53 177.93,31.53 178.24,31.84 178.92,31.84
N52922958 on TOP (solid shape): 181.08,31.81 181.08,30.39 181.26,30.2 181.42,30.2 181.53,30.18 181.64,30.2 182.96,30.2 183.13,30.03 183.13,29.45 183.03,29.35 180.52,29.35 180.37,29.5 180.37,31.81 180.44,31.89 181,31.89
N52925836 on TOP (solid shape): 50.27,21.57 50.27,20.91 50.19,20.84 48.79,20.84 48.59,21.04 48.3,21.04 48.22,21.12 48.22,22.11 48.3,22.18 49.66,22.18
N52925896 on TOP (solid shape): 50.29,19.36 50.29,18.75 50.14,18.6 50.14,18.41 50.07,18.36 50.02,18.3 49.96,18.26 49.89,18.28 49.36,17.91 49.97,17.73 50.04,17.76 50.12,17.73 50.14,17.71 50.14,17.23 49.51,16.6 48.79,16.6 47.93,17.46 47.93,19.03 48.08,19.19 48.7,19.19 49.04,19.52 50.14,19.52
N52930519 on TOP (solid shape): 40.36,44.15 40.36,42.25 40.23,42.12 39.22,42.12 38.31,43.03 38.31,43.07 38.27,43.07 38.2,43.14 37.69,43.14 37.57,43.27 37.57,43.9 37.69,44.03 38.58,44.03 38.84,44.28 40.23,44.28
N52930575 on TOP (solid shape): 36.42,45.42 36.42,44.66 36.25,44.48 36.25,43.21 36.17,43.14 35.41,43.14 35.15,43.39 35.15,44.1 35.15,44.15 35.16,44.16 35.18,44.28 35.16,44.39 35.15,44.4 35.15,44.46 34.9,44.72 34.9,45.42 35.03,45.55 36.3,45.55
N52934489 on TOP (solid shape): 28.74,41.99 28.95,41.92 29.17,42 29.44,42 30.01,41.42 30.18,41.42 30.23,41.41 30.28,41.41 31.37,41.41 31.37,41.42 31.6,41.42 31.79,41.23 32.36,41.23 32.49,41.11 32.49,40.6 32.36,40.47 30.25,40.47 30.23,40.5 30.23,40.55 29.97,40.8 29.95,40.83 28.52,40.83 28.42,40.93 28.42,41.74 28.68,42 28.72,42
N52934545 on TOP (solid shape): 34.77,41.11 34.77,39.2 34.65,39.07 33.88,39.07 33.76,39.2 33.76,41.11 33.88,41.23 34.65,41.23
N55952897 on TOP (solid shape): 170.38,43.01 170.66,43.01 170.92,42.76 170.92,42.25 171.02,42.15 171.02,42.15 171.3,41.87 172.77,41.87 172.79,41.84 172.81,41.81 172.84,41.74 172.81,41.67 172.89,41.09 173.4,41.37 173.41,41.38 173.55,41.52 173.84,41.23 173.84,39.96 173.71,39.84 171.04,39.84 170.79,40.09 170.79,41.36 170.39,41.76 169.5,41.76 169.45,41.81 169.45,42.95 169.51,43.01 170.38,43.01
N56035968 on TOP (solid shape): 176.76,80.6 176.76,78.83 177.27,78.32 177.27,76.67 177.01,76.41 177.01,75.02 176.76,74.76 176.25,74.76 176.14,74.65 174.19,74.65 174.15,74.69 174.15,75.84 174.21,75.9 175.11,75.9 175.49,76.29 175.49,79.59 175.51,79.61 175.51,80.68 175.62,80.78 176.58,80.78
N56041706 on TOP (solid shape): 169.32,37.02 170.82,37.02 170.93,36.9 170.93,36.03 170.41,35.51 170.41,34.76 170.84,34.32 170.84,33.81 170.73,33.69 170.73,33.68 170.15,33.1 170.15,31.12 169.74,31.12 169.74,33.21 169.09,33.87 168.76,33.87 168.63,33.99 168.63,37.02 168.71,37.09 169.24,37.09
N56704068 on BOTTOM (solid shape): 35.15,77.56 34.65,77.05 34.65,76.54 34.52,76.41 34.27,76.41 33.88,76.79 33.88,79.08 34.01,79.21 35.15,79.21
N56715138 on BOTTOM (solid shape): 50.78,80.69 50.78,78.45 50.69,78.36 48.57,78.36 48.49,78.44 48.11,78.44 47.98,78.57 47.98,80.35 48.4,80.77 50.7,80.77
N56728350 on BOTTOM (solid shape): 55.79,55.14 55.79,54.82 55.54,54.57 55.54,53.81 55.41,53.68 55.11,53.68 54.84,53.4 54.84,53.35 54.84,52.03 54.65,51.83 54.63,51.83 54.57,51.81 54.52,51.77 54.36,51.77 54.35,51.81 53.87,52.05 53.69,51.55 53.69,51.44 53.6,51.39 52.7,51.39 52.05,52.04 52.05,52.54 52.37,52.86 53.03,52.86 53.54,53.37 53.54,54.79 53.95,55.2 55.73,55.2
N56744237 on BOTTOM (solid shape): 44.43,78.95 44.43,77.43 44.3,77.3 43.79,77.3 43.54,77.05 43.53,77.05 43.38,76.9 41.19,76.9 41.13,76.96 41.13,77.41 41.17,77.45 42.49,77.45 42.78,77.59 42.84,77.9 42.84,77.9 42.84,78.01 42.65,78.2 41.16,78.2 41.12,78.24 41.12,78.7 41.25,78.86 41.27,79.06 41.26,79.09 41.38,79.21 44.17,79.21
N56767142 on BOTTOM (solid shape): 90.53,17.36 90.53,16.72 90.45,16.65 90.37,16.65 90.36,16.66 90.08,16.75 89.83,16.6 89,16.6 88.88,16.72 88.88,17.36 89,17.48 90.4,17.48
N57177583 on TOP (solid shape): 153.69,76.78 153.69,76.37 153.69,75.84 154.22,75.9 154.66,75.9 154.79,75.78 154.79,74.3 154.66,74.18 153.9,74.18 153.44,74.63 152.98,74.63 152.93,74.68 152.93,75.68 152.68,75.93 152.68,76.79 152.8,76.91 153.55,76.91
N57177931 on TOP (solid shape): 162.41,48.09 162.41,46.82 162.28,46.69 161.9,46.69 161.65,46.95 160.63,46.95 160.5,47.08 160.5,48.09 160.56,48.14 161.57,48.14 161.72,48.29 162.2,48.29
N57178338 on TOP (solid shape): 163.8,67.14 163.8,65.56 163.81,65.38 163.67,65.26 163.62,65.09 163.62,65.07 163.59,65.05 163.59,64.9 163.55,64.86 161.77,64.86 161.65,64.98 161.65,65.2 162.02,65.2 162.03,65.19 162.54,65.52 162.03,65.84 162.02,65.83 161.82,65.83 161.75,65.91 161.75,66.81 161.82,66.89 162.79,66.89 163.17,67.27 163.68,67.27
N57965459 on BOTTOM (solid shape): outline of 94 points within 53.53,55.46 56.49,60.05
N60799730 on TOP (solid shape): 62.08,64.73 62.84,64.73 63.09,64.47 63.09,63.59 63,63.49 62.43,63.49 62.03,63.89 61.04,63.89 60.94,63.99 60.94,64.73 61.06,64.86 61.95,64.86
N60799730 on BOTTOM (solid shape): 73.89,68.03 73.89,65.36 74.27,64.98 74.27,62.95 74.27,62.95 74.27,62.82 74.23,62.78 74.03,62.78 73.98,62.73 73.98,62.1 74.14,61.94 74.14,61.93 74.27,61.81 74.27,60.98 74.14,60.85 71.73,60.85 71.48,61.11 71.48,62.7 70.84,63.33 68.05,63.33 68.05,64.35 70.84,64.35 72.37,65.87 72.37,68.03 72.49,68.16 73.76,68.16
N60799730 on IN3 (solid shape): outline of 153 points within 61.95,63.59 73.76,68.79
N60799760 on TOP (solid shape): 63.09,62 63.09,61.13 63.09,60.34 62.85,60.09 62.53,60.09 62.21,60.42 62.21,61.93 62.34,62.07 63.02,62.07
N60799760 on BOTTOM (solid shape): 71.22,62.06 71.22,61.43 70.97,61.17 70.33,61.17 70.09,61.42 70.09,62.17 70.2,62.28 71.01,62.28
N60799760 on IN3 (solid shape): 63.09,62.19 63.09,60.16 62.84,59.9 62.46,59.9 62.21,60.16 62.21,62.19 62.46,62.44 62.84,62.44
N60799760 on IN3 (solid shape): 71.22,62.06 71.22,61.43 70.97,61.17 70.33,61.17 69.71,61.79 69.33,61.79 69.32,61.81 69.32,62.44 69.57,62.7 70.59,62.7
N60799765 on TOP (solid shape): 65.38,64.35 65.38,63.71 65.15,63.49 64.4,63.49 64.33,63.55 64.33,64.44 64.49,64.6 65.13,64.6
N60799765 on BOTTOM (solid shape): 71.1,65.36 71.1,64.98 70.64,64.53 70.15,64.53 70.08,64.6 70.08,65.74 70.21,65.87 70.59,65.87
N60799765 on IN3 (solid shape): 71.1,66.4 71.1,64.98 70.64,64.52 70.16,64.52 70.08,64.6 70.08,66.4 70.26,66.58 70.92,66.58
N60799765 on IN3 (solid shape): 65.51,65.08 65.51,64.73 65.38,64.6 65.38,63.71 65.15,63.48 64.41,63.48 64.34,63.56 64.34,64.45 64.49,64.6 64.49,65.11 64.67,65.29 65.3,65.29
N60799776 on TOP (solid shape): 63.59,62 63.59,61.25 63.73,61.11 63.73,60.12 63.67,60.05 63.26,60.05 63.22,60.09 63.22,61.07 63.34,61.19 63.34,62.02 63.4,62.07 63.52,62.07
N62098363 on TOP (solid shape): 202.41,41.23 202.41,37.65 202.36,37.6 200.36,37.6 200.33,37.63 200.33,39 200.84,39.51 200.84,41.18 200.97,41.31 202.34,41.31
N65247919 on TOP (solid shape): 37.1,36.31 37.38,36.31 37.45,36.23 37.45,35.77 37.28,35.59 36.67,35.59 36.51,35.44 36.51,34.75 36.48,34.72 36.4,34.6 36.37,34.46 36.34,34.39 36.27,34.36 35.85,34.36 35.75,34.46 35.75,36.36 36.03,36.64 36.77,36.64
N66930423 on TOP (solid shape): 183.38,47.85 183.38,47.32 183.54,47.15 183.54,46.93 183.52,46.91 182.48,46.91 182.24,46.67 181.08,46.67 180.97,46.77 180.97,48.13 181.09,48.25 182.98,48.25
N119009632 on BOTTOM (solid shape): 31.46,75.4 31.85,75.4 31.98,75.27 31.98,74.77 31.92,74.71 31.88,74.73 31.58,74.75 31.37,74.53 31.36,74.5 31.14,74.5 31.14,74.5 30.68,74.5 30.66,74.53 30.34,74.74 30.02,74.54 30.01,74.51 29.31,74.51 28.93,74.89 28.93,75.85 29.19,76.11 30.75,76.11

Small or netless copper shapes (teardrops, artwork): 18 on TOP, 19 on BOTTOM, 5 on IN2, 1 on IN3, 1 on IN4

## Text on the board
Ref Des/Silkscreen Bottom: RTC | Battery | DC-IN | Speaker | WLAN+BT | Board | Keyboard | Camera | Touch | Screen | Fan | Touch Pad | LCD | IO Board | UART | H11 | H14 | H16 | H15 | H10 | H6 | H17
User.Comments: LA-D841P | 2016-06-21 | 2017-06-21 | CAZ00 | Win
User.10: LAYER | NAME | L3 | L1 | L2 | L5 | L4 | L6 | L7 | L8 | L9 | L10 | LA-D841P | GND2 | VCC | TOP | GND1 | IN2 | IN3 | IN4 | IN1 | GND3 | BOT | LS-XXXXP
User.38: FIGURE | SIZE | 8.0 | 10.0 | 16.0 | 26.0 | 31.0 | 79.0 | 130.0 | 30.0 | 40.0 | 43.0 | 63.0 | 71.0 | 51.0x31.0 | 55.0x24.0 | 63.0x24.0 | 75.0x31.0 | 126.0x31.0 | 37.0x30.0 | 91.0x71.0 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | TOLERANCE | +3.0/-3.0 | +2.0/-2.0 | PLATED | NON-PLATED | QTY | 5205 | 54 | 12 | 2 | 9 | 8 | 7 | 1 | 4
User.39: trace Width | 4.6 | 3.2 | 3.5 | 5 | Width/Space | 4.5/3.5 | 3.6/4 | 4/4.8 | 5/5 | 4 | 4/4.4 | L4/L6 | 6.4/3.5 | L3 | L8 | L9-GND3 | L4-GND2 | L10-BOT | L6-IN3 | L3-IN1 | L5-IN2 | L7-VCC | L2-GND1 | HR_1_0mm-10L-stack-up-150429.pdf | L1-TOP | L8-IN4 | LAYER | NAME | STACKUP: 10 LAYER | 40 ohm | 50 ohm | 75 ohm | THICKNESS=1.0mm | 85 ohm | ref | 90 ohm
